<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fmradio</value></param>
<param><key>author</key><value>Pranav</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>An FM radio with Coarse and Fine scrubbing</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FMRadio</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bass</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Bass</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>100.1e6</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>80e6</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>120e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel_slider</value></param>
<param><key>value</key><value>center_freq</value></param>
<param><key>label</key><value>Fine tuning</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>center_freq-samp_rate/2+channel_width/2</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>center_freq+samp_rate/2-channel_width/2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>high</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Treble</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mids</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>MIds</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.5e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume_slider</value></param>
<param><key>value</key><value>5</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq-channel_slider</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>quad_rate</key><value>480</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume_slider</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>bass</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>mids</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>high</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[-5.94641242059879e-05, -5.7774352171691135e-05, -5.607017010333948e-05, -5.435314233181998e-05, -5.2624844101956114e-05, -5.088686157250777e-05, -4.914080273010768e-05, -4.7388297389261425e-05, -4.5630957174580544e-05, -4.387044100440107e-05, -4.210840415908024e-05, -4.034651647089049e-05, -3.8586458686040714e-05, -3.6829929740633816e-05, -3.507862129481509e-05, -3.3334250474581495e-05, -3.1598538043908775e-05, -2.987320658576209e-05, -2.815999323502183e-05, -2.6460644221515395e-05, -2.4776898499112576e-05, -2.3110515030566603e-05, -2.146324550267309e-05, -1.983685069717467e-05, -1.8233091395813972e-05, -1.665373201831244e-05, -1.5100532436918002e-05, -1.3575258890341502e-05, -1.207967125083087e-05, -1.061553030012874e-05, -9.184589544020128e-06, -7.78860066930065e-06, -6.429308541555656e-06, -5.108450750412885e-06, -3.827758519037161e-06, -2.5889512471621856e-06, -1.393740035382507e-06, -2.438232513668481e-07, 8.591140385760809e-07, 1.9134010926791234e-06, 2.9173829716455657e-06, 3.869422471325379e-06, 4.767900009028381e-06, 5.611218057310907e-06, 6.397799097612733e-06, 7.12608971298323e-06, 7.794561497576069e-06, 8.401711966143921e-06, 8.94606546353316e-06, 9.426180440641474e-06, 9.840641723712906e-06, 1.0188069609284867e-05, 1.0467118954693433e-05, 1.067647917807335e-05, 1.0814884262799751e-05, 1.0881099115067627e-05, 1.0873936844291165e-05, 1.0792251487146132e-05, 1.0634946193022188e-05, 1.0400964129075874e-05, 1.008930576062994e-05, 9.699014299258124e-06, 9.229192983184475e-06, 8.678995982336346e-06, 8.047632036323193e-06, 7.334370820899494e-06, 6.538541128975339e-06, 5.6595326896058396e-06, 4.696799805969931e-06, 3.649859763754648e-06, 2.5182989702443592e-06, 1.3017710216445266e-06, -8.446716050994029e-20, -1.3872183899366064e-06, -2.86001500171551e-06, -4.41844576926087e-06, -6.062489319447195e-06, -7.792049473209772e-06, -9.60694615059765e-06, -1.1506924238346983e-05, -1.3491639947460499e-05, -1.5560670362901874e-05, -1.771351344359573e-05, -1.9949569832533598e-05, -2.2268161046667956e-05, -2.466852129145991e-05, -2.7149793822900392e-05, -2.9711038223467767e-05, -3.2351217669202015e-05, -3.506920256768353e-05, -3.786378147196956e-05, -4.073364834766835e-05, -4.3677409848896787e-05, -4.669355621444993e-05, -4.978052311344072e-05, -5.293662252370268e-05, -5.616008638753556e-05, -5.944906297372654e-05, -6.280159141169861e-05, -6.621562351938337e-05, -6.96890419931151e-05, -7.321961311390623e-05, -7.680501585127786e-05, -8.04428564151749e-05, -8.41306391521357e-05, -8.78657738212496e-05, -9.164562652586028e-05, -9.546741785015911e-05, -9.932833927450702e-05, -0.00010322547313990071, -0.00010715582902776077, -0.00011111635103588924, -0.00011510388139868155, -0.00011911520414287224, -0.00012314703781157732, -0.00012719603546429425, -0.00013125877012498677, -0.0001353317784378305, -0.00013941146607976407, -0.00014349428238347173, -0.0001475765457144007, -0.000151654559886083, -0.00015572455595247447, -0.0001597827795194462, -0.00016382533067371696, -0.00016784838226158172, -0.00017184799071401358, -0.00017582022701390088, -0.00017976114759221673, -0.0001836667361203581, -0.0001875329908216372, -0.0001913559390231967, -0.0001951314916368574, -0.00019885567598976195, -0.00020252444664947689, -0.00020613377273548394, -0.00020967965247109532, -0.00021315811318345368, -0.00021656510944012552, -0.00021989678498357534, -0.0002231491671409458, -0.00022631835599895567, -0.00022940053895581514, -0.00023239190340973437, -0.00023528870951849967, -0.00023808726109564304, -0.00024078394926618785, -0.000243375136051327, -0.00024585743085481226, -0.0002482273557689041, -0.0002504815929569304, -0.0002526169118937105, -0.0002546301402617246, -0.0002565181930549443, -0.00025827818899415433, -0.00025990727590397, -0.00026140271802432835, -0.0002627618669066578, -0.0002639823069330305, -0.0002650616515893489, -0.0002659976598806679, -0.00026678823633119464, -0.0002674315182957798, -0.0002679256722331047, -0.00026826909743249416, -0.000268460251390934, -0.00026849782443605363, -0.00026838071062229574, -0.00026810786221176386, -0.0002676785225048661, -0.000267092022113502, -0.00026634795358404517, -0.00026544599677436054, -0.00026438606437295675, -0.00026316833100281656, -0.00026179305859841406, -0.0002602606837172061, -0.00025857199216261506, -0.00025672782794572413, -0.0002547293552197516, -0.00025257779634557664, -0.000250274664722383, -0.00024782170657999814, -0.0002452208718750626, -0.00024247421242762357, -0.000239584143855609, -0.0002365531981922686, -0.00023338412574958056, -0.00023007990967016667, -0.00022664375137537718, -0.00022307902690954506, -0.00021938934514764696, -0.00021557848958764225, -0.00021165053476579487, -0.00020760964252986014, -0.00020346028031781316, -0.0001992070465348661, -0.00019485477241687477, -0.00019040846382267773, -0.00018587334488984197, -0.000181254799827002, -0.00017655840201769024, -0.00017178995767608285, -0.00016695534577593207, -0.0001620607217773795, -0.0001571123139001429, -0.00015211662685032934, -0.00014708020898979157, -0.0001420098269591108, -0.0001369123492622748, -0.00013179484813008457, -0.00012666446855291724, -0.00012152851559221745, -0.0001163943816209212, -0.00011126959725515917, -0.00010616180225042626, -0.00010107870912179351, -9.602814679965377e-05, -9.101800242206082e-05, -8.60562504385598e-05, -8.115093078231439e-05, -7.631012704223394e-05, -7.154198829084635e-05, -6.685467815259472e-05, -6.225642573554069e-05, -5.775543468189426e-05, -5.33599522896111e-05, -4.9078214942710474e-05, -4.491844811127521e-05, -4.0888855437515303e-05, -3.699762964970432e-05, -3.325289799249731e-05, -2.9662754968740046e-05, -2.623522959765978e-05, -2.2978283595875837e-05, -1.989979500649497e-05, -1.7007550923153758e-05, -1.430923930456629e-05, -1.1812433513114229e-05, -9.524582310405094e-06, -7.453005764546106e-06, -5.604877514997497e-06, -3.9872156776255e-06, -2.6068764782394283e-06, -1.4705386774949147e-06, -5.846970339007385e-07, 4.434991751622874e-08, 4.1050910226658743e-07, 5.079031666355149e-07, 3.308805389679037e-07, -1.2597544696291152e-07, -8.678364906700153e-07, -1.8996200878973468e-06, -3.2259802082990063e-06, -4.851298854191555e-06, -6.7796763687510975e-06, -9.014923307404388e-06, -1.1560552593437023e-05, -1.4419769286178052e-05, -1.759547012625262e-05, -2.109021988871973e-05, -2.490626684448216e-05, -2.9045513656456023e-05, -3.3509528293507174e-05, -3.829952038358897e-05, -4.34163557656575e-05, -4.8860532842809334e-05, -5.463218622026034e-05, -6.073108306736685e-05, -6.71566158416681e-05, -7.390778773697093e-05, -8.09832417871803e-05, -8.838120993459597e-05, -9.609954577172175e-05, -0.00010413570271339267, -0.00011248677765252069, -0.00012114943092456087, -0.00013011993723921478, -0.00013939417840447277, -0.0001489676651544869, -0.00015883546438999474, -0.00016899227921385318, -0.0001794324052752927, -0.00019014973076991737, -0.00020113782375119627, -0.00021238978661131114, -0.0002238983433926478, -0.00023565589799545705, -0.00024765441776253283, -0.0002598855353426188, -0.0002723404613789171, -0.0002850101445801556, -0.00029788509709760547, -0.0003109555400442332, -0.0003242112579755485, -0.0003376418026164174, -0.00035123637644574046, -0.0003649838618002832, -0.00037887279177084565, -0.00039289146661758423, -0.00040702789556235075, -0.00042126973858103156, -0.0004356044519226998, -0.0004500193172134459, -0.00046450115041807294, -0.000479036767501384, -0.0004936125478707254, -0.000508215045556426, -0.0005228301743045449, -0.000537443847861141, -0.0005520419217646122, -0.0005666100769303739, -0.0005811336450278759, -0.0005955981905572116, -0.0006099888705648482, -0.0006242909003049135, -0.0006384894368238747, -0.000652569520752877, -0.0006665163091383874, -0.0006803146097809076, -0.0006939496379345655, -0.0007074063178151846, -0.0007206698064692318, -0.0007337252609431744, -0.0007465576636604965, -0.0007591524627059698, -0.000771495106164366, -0.0007835709839127958, -0.0007953657186590135, -0.000806865282356739, -0.0008180555887520313, -0.0008289228426292539, -0.0008394534816034138, -0.0008496341179125011, -0.0008594516548328102, -0.0008688931702636182, -0.0008779463241808116, -0.0008865988347679377, -0.0008948387112468481, -0.0009026543120853603, -0.0009100346942432225, -0.0009169687982648611, -0.0009234463213942945, -0.0009294571354985237, -0.0009349916945211589, -0.0009400408016517758, -0.0009445959003642201, -0.0009486486669629812, -0.0009521911852061749, -0.0009552165865898132, -0.0009577178861945868, -0.0009596890304237604, -0.0009611241985112429, -0.0009620185010135174, -0.0009623672813177109, -0.0009621666977182031, -0.000961413374170661, -0.0009601045749150217, -0.0009582380880601704, -0.0009558125166222453, -0.0009528268710710108, -0.0009492810349911451, -0.000945175183005631, -0.0009405106538906693, -0.0009352888446301222, -0.0009295124327763915, -0.0009231841540895402, -0.0009163079084828496, -0.0009088880615308881, -0.0009009296190924942, -0.0008924382855184376, -0.0008834206964820623, -0.0008738836622796953, -0.0008638350991532207, -0.0008532834472134709, -0.0008422378450632095, -0.0008307080715894699, -0.0008187045459635556, -0.0008062385022640228, -0.0007933216402307153, -0.0007799664163030684, -0.0007661859854124486, -0.0007519939099438488, -0.0007374047418124974, -0.0007224332657642663, -0.0007070951396599412, -0.0006914065452292562, -0.0006753841298632324, -0.000659045297652483, -0.0006424079183489084, -0.0006254905019886792, -0.0006083117914386094, -0.0005908913444727659, -0.0005732491263188422, -0.0005554055678658187, -0.0005373815656639636, -0.00051919836550951, -0.0005008779116906226, -0.0004824420902878046, -0.00046391363139264286, -0.0004453152942005545, -0.00042667039087973535, -0.00040800237911753356, -0.00038933512405492365, -0.0003706926654558629, -0.00035209936322644353, -0.0003335796936880797, -0.0003151584242004901, -0.00029686043853871524, -0.0002787107659969479, -0.00026073449407704175, -0.0002429568558000028, -0.00022540311329066753, -0.0002080985577777028, -0.0001910684659378603, -0.0001743380562402308, -0.0001579325762577355, -0.0001418770698364824, -0.00012619653716683388, -0.00011091581109212711, -9.605952800484374e-05, -8.165212057065219e-05, -6.771778862457722e-05, -5.4280459153233096e-05, -4.1363757190993056e-05, -2.8990974897169508e-05, -1.7185058823088184e-05, -5.968548521195771e-06, 4.636424364434788e-06, 1.460818384657614e-05, 2.3925524146761745e-05, 3.256775380577892e-05, 4.051471478305757e-05, 4.774680201080628e-05, 5.424502523965202e-05, 5.999099084874615e-05, 6.496697460534051e-05, 6.915591075085104e-05, 7.25414211046882e-05, 7.510787690989673e-05, 7.684040610911325e-05, 7.772487151669338e-05, 7.774798723403364e-05, 7.689724588999525e-05, 7.516102050431073e-05, 7.252850627992302e-05, 6.898985157022253e-05, 6.453604873968288e-05, 5.915906513109803e-05, 5.2851781219942495e-05, 4.560805973596871e-05, 3.742273838724941e-05, 2.8291666239965707e-05, 1.821168370952364e-05, 7.18066667104722e-06, -4.80246990264277e-06, -1.77377623913344e-05, -3.162418579449877e-05, -4.6459641453111544e-05, -6.224095704965293e-05, -7.8963850683067e-05, -9.662298543844372e-05, -0.00011521190754137933, -0.00013472304271999747, -0.00015514773258473724, -0.00017647621280048043, -0.0001986975985346362, -0.00022179986990522593, -0.0002457700320519507, -0.0002705937949940562, -0.00029625592287629843, -0.0003227400011382997, -0.00035002868389710784, -0.0003781032864935696, -0.000406944309361279, -0.00043653108878061175, -0.0004668418550863862, -0.0004978540237061679, -0.0005295437294989824, -0.0005618863506242633, -0.0005948561010882258, -0.0006284263217821717, -0.000662569422274828, -0.0006972569390200078, -0.0007324593607336283, -0.0007681464776396751, -0.0008042871486395597, -0.0008408492431044579, -0.000877800106536597, -0.0009151063277386129, -0.0009527335059829056, -0.0009906466584652662, -0.0010288102785125375, -0.0010671879863366485, -0.0011057429946959019, -0.0011444377014413476, -0.0011832340387627482, -0.0012220938224345446, -0.0012609778204932809, -0.0012998468009755015, -0.0013386609498411417, -0.0013773798709735274, -0.001415963633917272, -0.0014543712604790926, -0.0014925620052963495, -0.0015304946573451161, -0.0015681280056014657, -0.0016054208390414715, -0.001642331713810563, -0.0016788194188848138, -0.0017148427432402968, -0.0017503600101917982, -0.0017853305907920003, -0.00181971350684762, -0.001853468012996018, -0.0018865537131205201, -0.0019189307931810617, -0.0019505593227222562, -0.0019814001861959696, -0.00201141438446939, -0.0020405640825629234, -0.0020688113290816545, -0.0020961188711225986, -0.0021224503871053457, -0.0021477702539414167, -0.0021720430813729763, -0.0021952351089566946, -0.002217313041910529, -0.0022382440511137247, -0.0022579964715987444, -0.0022765405010432005, -0.0022938456386327744, -0.0023098839446902275, -0.002324627945199609, -0.0023380510974675417, -0.002350128721445799, -0.0023608366027474403, -0.0023701523896306753, -0.0023780546616762877, -0.0023845231626182795, -0.0023895397316664457, -0.0023930869065225124, -0.0023951490875333548, -0.0023957116063684225, -0.0023947618901729584, -0.0023922882974147797, -0.002388281747698784, -0.002382733393460512, -0.002375636948272586, -0.0023669868241995573, -0.00235678069293499, -0.002345016226172447, -0.0023316938895732164, -0.002316814847290516, -0.002300382824614644, -0.002282403176650405, -0.002262882189825177, -0.002241829177364707, -0.0022192541509866714, -0.002195169450715184, -0.002169588580727577, -0.0021425276063382626, -0.0021140039898455143, -0.0020840370561927557, -0.0020526472944766283, -0.0020198579877614975, -0.001985693583264947, -0.0019501796923577785, -0.0019133450696244836, -0.0018752189353108406, -0.0018358329543843865, -0.0017952199559658766, -0.0017534148646518588, -0.0017104542348533869, -0.001666375668719411, -0.0016212192131206393, -0.0015750257298350334, -0.0015278379432857037, -0.0014797005569562316, -0.0014306589728221297, -0.0013807604555040598, -0.0013300536666065454, -0.0012785884318873286, -0.001226416090503335, -0.001173589495010674, -0.001120162196457386, -0.0010661896085366607, -0.001011727494187653, -0.0009568335372023284, -0.0009015660616569221, -0.0008459843811579049, -0.0007901489734649658, -0.0007341210730373859, -0.0006779626710340381, -0.0006217368645593524, -0.0005655071581713855, -0.0005093379295431077, -0.00045329390559345484, -0.0003974407445639372, -0.00034184427931904793, -0.0002865708665922284, -0.00023168721236288548, -0.00017726034275256097, -0.0001233574002981186, -7.004578947089612e-05, -1.739291474223137e-05, 3.453378667472862e-05, 8.566692849854007e-05, 0.00013593927724286914, 0.00018528380314819515, 0.00023363373475149274, 0.0002809226862154901, 0.00032708465005271137, 0.00037205417174845934, 0.0004157662915531546, 0.00045815674820914865, 0.0004991620662622154, 0.0005387194105423987, 0.0005767669063061476, 0.0006132436683401465, 0.0006480896263383329, 0.0006812461069785058, 0.0007126553100533783, 0.0007422606577165425, 0.0007700072601437569, 0.0007958410424180329, 0.000819709908682853, 0.0008415627526119351, 0.0008613506215624511, 0.0008790255524218082, 0.0008945419103838503, 0.0009078554576262832, 0.0009189239353872836, 0.0009277068893425167, 0.0009341659606434405, 0.000938264885917306, 0.0009399691480211914, 0.0009392465581186116, 0.0009360673138871789, 0.0009304035920649767, 0.0009222300723195076, 0.0009115234715864062, 0.0008982632425613701, 0.0008824311080388725, 0.0008640115265734494, 0.0008429909939877689, 0.0008193590911105275, 0.0007931076106615365, 0.0007642313139513135, 0.0007327274652197957, 0.0006985960644669831, 0.0006618397892452776, 0.0006224642274901271, 0.000580477702897042, 0.0005358912167139351, 0.0004887187969870865, 0.0004389771493151784, 0.0003866859769914299, 0.0003318677481729537, 0.000274547899607569, 0.0002147546474589035, 0.00015251916192937642, 8.787547994870692e-05, 2.0860532458755188e-05, -4.848589378525503e-05, -0.00012012111983494833, -0.00019399961456656456, -0.00027007306925952435, -0.00034829016658477485, -0.0004285970062483102, -0.0005109367775730789, -0.0005952499341219664, -0.0006814741063863039, -0.0007695445674471557, -0.0008593933307565749, -0.0009509504307061434, -0.0010441428748890758, -0.001138895284384489, -0.0012351296609267592, -0.0013327657943591475, -0.0014317207969725132, -0.0015319096855819225, -0.0016332447994500399, -0.001735636848025024, -0.0018389937467873096, -0.0019432216649875045, -0.002048224676400423, -0.0021539044100791216, -0.0022601617965847254, -0.0023668943904340267, -0.0024739992804825306, -0.002581370994448662, -0.002688902895897627, -0.0027964869514107704, -0.0029040127992630005, -0.003011370310559869, -0.003118446795269847, -0.0032251288648694754, -0.003331301733851433, -0.003436849918216467, -0.0035416572354733944, -0.003645606804639101, -0.0037485798820853233, -0.003850458888337016, -0.003951123915612698, -0.004050456453114748, -0.004148336127400398, -0.00424464326351881, -0.004339258186519146, -0.00443206075578928, -0.004522931296378374, -0.00461175013333559, -0.004698398523032665, -0.004782756790518761, -0.004864707589149475, -0.004944132640957832, -0.0050209155306220055, -0.005094940774142742, -0.00516609288752079, -0.005234259180724621, -0.005299325566738844, -0.0053611816838383675, -0.005419717635959387, -0.005474825389683247, -0.005526397842913866, -0.005574330687522888, -0.005618520546704531, -0.005658866371959448, -0.00569526944309473, -0.005727632436901331, -0.005755861289799213, -0.005779863800853491, -0.0057995496317744255, -0.0058148326352238655, -0.005825627129524946, -0.005831851623952389, -0.0058334278874099255, -0.005830279551446438, -0.005822333041578531, -0.005809519439935684, -0.005791771225631237, -0.005769025068730116, -0.005741221364587545, -0.005708302371203899, -0.005670215468853712, -0.005626911763101816, -0.005578343756496906, -0.005524470936506987, -0.005465252790600061, -0.005400655325502157, -0.005330648273229599, -0.005255203694105148, -0.005174298770725727, -0.005087914876639843, -0.004996037110686302, -0.004898654296994209, -0.004795760381966829, -0.004687352105975151, -0.004573431797325611, -0.004454005043953657, -0.004329082556068897, -0.004198678303509951, -0.004062811844050884, -0.003921505529433489, -0.0037747870665043592, -0.003622688353061676, -0.0034652450121939182, -0.0033024982549250126, -0.0031344923190772533, -0.0029612763319164515, -0.0027829036116600037, -0.0025994323659688234, -0.002410923596471548, -0.0022174438927322626, -0.002019063336774707, -0.0018158572493121028, -0.0016079036286100745, -0.0013952853623777628, -0.0011780895292758942, -0.0009564067586325109, -0.0007303321035578847, -0.000499964167829603, -0.0002654057461768389, -2.676319854799658e-05, 0.00021585333161056042, 0.00046232997556217015, 0.0007125493139028549, 0.0009663903620094061, 0.001223728759214282, 0.001484436565078795, 0.0017483829287812114, 0.002015433507040143, 0.0022854506969451904, 0.0025582946836948395, 0.0028338213451206684, 0.0031118851620703936, 0.003392336890101433, 0.0036750254221260548, 0.003959796857088804, 0.004246493335813284, 0.004534958396106958, 0.004825029522180557, 0.005116544663906097, 0.005409338045865297, 0.005703243426978588, 0.005998092237859964, 0.006293714977800846, 0.006589939817786217, 0.006886593531817198, 0.0071835024282336235, 0.007480490952730179, 0.007777384482324123, 0.008074004203081131, 0.0083701740950346, 0.008665715344250202, 0.008960448205471039, 0.009254196658730507, 0.009546780958771706, 0.00983802042901516, 0.010127737186849117, 0.010415753349661827, 0.010701890103518963, 0.010985970497131348, 0.01126781664788723, 0.011547253467142582, 0.011824105866253376, 0.012098198756575584, 0.012369358912110329, 0.012637416832149029, 0.01290220208466053, 0.013163545168936253, 0.013421280309557915, 0.013675243593752384, 0.013925271108746529, 0.014171202667057514, 0.014412879943847656, 0.014650147408246994, 0.01488285232335329, 0.015110841952264309, 0.015333971939980984, 0.015552094206213951, 0.01576506718993187, 0.01597275398671627, 0.01617501676082611, 0.016371725127100945, 0.016562748700380325, 0.016747960820794106, 0.016927244141697884, 0.01710047572851181, 0.01726754568517208, 0.017428340390324593, 0.017582757398486137, 0.01773068867623806, 0.017872044816613197, 0.01800672523677349, 0.018134642392396927, 0.01825571060180664, 0.018369851633906364, 0.01847699098289013, 0.018577054142951965, 0.0186699740588665, 0.01875569112598896, 0.018834147602319717, 0.018905291333794594, 0.01896907389163971, 0.01902545429766178, 0.019074391573667526, 0.019115855917334557, 0.019149819388985634, 0.019176257774233818, 0.019195158034563065, 0.01920650154352188, 0.01921028457581997, 0.01920650154352188, 0.019195158034563065, 0.019176257774233818, 0.019149819388985634, 0.019115855917334557, 0.019074391573667526, 0.01902545429766178, 0.01896907389163971, 0.018905291333794594, 0.018834147602319717, 0.01875569112598896, 0.0186699740588665, 0.018577054142951965, 0.01847699098289013, 0.018369851633906364, 0.01825571060180664, 0.018134642392396927, 0.01800672523677349, 0.017872044816613197, 0.01773068867623806, 0.017582757398486137, 0.017428340390324593, 0.01726754568517208, 0.01710047572851181, 0.016927244141697884, 0.016747960820794106, 0.016562748700380325, 0.016371725127100945, 0.01617501676082611, 0.01597275398671627, 0.01576506718993187, 0.015552094206213951, 0.015333971939980984, 0.015110841952264309, 0.01488285232335329, 0.014650147408246994, 0.014412879943847656, 0.014171202667057514, 0.013925271108746529, 0.013675243593752384, 0.013421280309557915, 0.013163545168936253, 0.01290220208466053, 0.012637416832149029, 0.012369358912110329, 0.012098198756575584, 0.011824105866253376, 0.011547253467142582, 0.01126781664788723, 0.010985970497131348, 0.010701890103518963, 0.010415753349661827, 0.010127737186849117, 0.00983802042901516, 0.009546780958771706, 0.009254196658730507, 0.008960448205471039, 0.008665715344250202, 0.0083701740950346, 0.008074004203081131, 0.007777384482324123, 0.007480490952730179, 0.0071835024282336235, 0.006886593531817198, 0.006589939817786217, 0.006293714977800846, 0.005998092237859964, 0.005703243426978588, 0.005409338045865297, 0.005116544663906097, 0.004825029522180557, 0.004534958396106958, 0.004246493335813284, 0.003959796857088804, 0.0036750254221260548, 0.003392336890101433, 0.0031118851620703936, 0.0028338213451206684, 0.0025582946836948395, 0.0022854506969451904, 0.002015433507040143, 0.0017483829287812114, 0.001484436565078795, 0.001223728759214282, 0.0009663903620094061, 0.0007125493139028549, 0.00046232997556217015, 0.00021585333161056042, -2.676319854799658e-05, -0.0002654057461768389, -0.000499964167829603, -0.0007303321035578847, -0.0009564067586325109, -0.0011780895292758942, -0.0013952853623777628, -0.0016079036286100745, -0.0018158572493121028, -0.002019063336774707, -0.0022174438927322626, -0.002410923596471548, -0.0025994323659688234, -0.0027829036116600037, -0.0029612763319164515, -0.0031344923190772533, -0.0033024982549250126, -0.0034652450121939182, -0.003622688353061676, -0.0037747870665043592, -0.003921505529433489, -0.004062811844050884, -0.004198678303509951, -0.004329082556068897, -0.004454005043953657, -0.004573431797325611, -0.004687352105975151, -0.004795760381966829, -0.004898654296994209, -0.004996037110686302, -0.005087914876639843, -0.005174298770725727, -0.005255203694105148, -0.005330648273229599, -0.005400655325502157, -0.005465252790600061, -0.005524470936506987, -0.005578343756496906, -0.005626911763101816, -0.005670215468853712, -0.005708302371203899, -0.005741221364587545, -0.005769025068730116, -0.005791771225631237, -0.005809519439935684, -0.005822333041578531, -0.005830279551446438, -0.0058334278874099255, -0.005831851623952389, -0.005825627129524946, -0.0058148326352238655, -0.0057995496317744255, -0.005779863800853491, -0.005755861289799213, -0.005727632436901331, -0.00569526944309473, -0.005658866371959448, -0.005618520546704531, -0.005574330687522888, -0.005526397842913866, -0.005474825389683247, -0.005419717635959387, -0.0053611816838383675, -0.005299325566738844, -0.005234259180724621, -0.00516609288752079, -0.005094940774142742, -0.0050209155306220055, -0.004944132640957832, -0.004864707589149475, -0.004782756790518761, -0.004698398523032665, -0.00461175013333559, -0.004522931296378374, -0.00443206075578928, -0.004339258186519146, -0.00424464326351881, -0.004148336127400398, -0.004050456453114748, -0.003951123915612698, -0.003850458888337016, -0.0037485798820853233, -0.003645606804639101, -0.0035416572354733944, -0.003436849918216467, -0.003331301733851433, -0.0032251288648694754, -0.003118446795269847, -0.003011370310559869, -0.0029040127992630005, -0.0027964869514107704, -0.002688902895897627, -0.002581370994448662, -0.0024739992804825306, -0.0023668943904340267, -0.0022601617965847254, -0.0021539044100791216, -0.002048224676400423, -0.0019432216649875045, -0.0018389937467873096, -0.001735636848025024, -0.0016332447994500399, -0.0015319096855819225, -0.0014317207969725132, -0.0013327657943591475, -0.0012351296609267592, -0.001138895284384489, -0.0010441428748890758, -0.0009509504307061434, -0.0008593933307565749, -0.0007695445674471557, -0.0006814741063863039, -0.0005952499341219664, -0.0005109367775730789, -0.0004285970062483102, -0.00034829016658477485, -0.00027007306925952435, -0.00019399961456656456, -0.00012012111983494833, -4.848589378525503e-05, 2.0860532458755188e-05, 8.787547994870692e-05, 0.00015251916192937642, 0.0002147546474589035, 0.000274547899607569, 0.0003318677481729537, 0.0003866859769914299, 0.0004389771493151784, 0.0004887187969870865, 0.0005358912167139351, 0.000580477702897042, 0.0006224642274901271, 0.0006618397892452776, 0.0006985960644669831, 0.0007327274652197957, 0.0007642313139513135, 0.0007931076106615365, 0.0008193590911105275, 0.0008429909939877689, 0.0008640115265734494, 0.0008824311080388725, 0.0008982632425613701, 0.0009115234715864062, 0.0009222300723195076, 0.0009304035920649767, 0.0009360673138871789, 0.0009392465581186116, 0.0009399691480211914, 0.000938264885917306, 0.0009341659606434405, 0.0009277068893425167, 0.0009189239353872836, 0.0009078554576262832, 0.0008945419103838503, 0.0008790255524218082, 0.0008613506215624511, 0.0008415627526119351, 0.000819709908682853, 0.0007958410424180329, 0.0007700072601437569, 0.0007422606577165425, 0.0007126553100533783, 0.0006812461069785058, 0.0006480896263383329, 0.0006132436683401465, 0.0005767669063061476, 0.0005387194105423987, 0.0004991620662622154, 0.00045815674820914865, 0.0004157662915531546, 0.00037205417174845934, 0.00032708465005271137, 0.0002809226862154901, 0.00023363373475149274, 0.00018528380314819515, 0.00013593927724286914, 8.566692849854007e-05, 3.453378667472862e-05, -1.739291474223137e-05, -7.004578947089612e-05, -0.0001233574002981186, -0.00017726034275256097, -0.00023168721236288548, -0.0002865708665922284, -0.00034184427931904793, -0.0003974407445639372, -0.00045329390559345484, -0.0005093379295431077, -0.0005655071581713855, -0.0006217368645593524, -0.0006779626710340381, -0.0007341210730373859, -0.0007901489734649658, -0.0008459843811579049, -0.0009015660616569221, -0.0009568335372023284, -0.001011727494187653, -0.0010661896085366607, -0.001120162196457386, -0.001173589495010674, -0.001226416090503335, -0.0012785884318873286, -0.0013300536666065454, -0.0013807604555040598, -0.0014306589728221297, -0.0014797005569562316, -0.0015278379432857037, -0.0015750257298350334, -0.0016212192131206393, -0.001666375668719411, -0.0017104542348533869, -0.0017534148646518588, -0.0017952199559658766, -0.0018358329543843865, -0.0018752189353108406, -0.0019133450696244836, -0.0019501796923577785, -0.001985693583264947, -0.0020198579877614975, -0.0020526472944766283, -0.0020840370561927557, -0.0021140039898455143, -0.0021425276063382626, -0.002169588580727577, -0.002195169450715184, -0.0022192541509866714, -0.002241829177364707, -0.002262882189825177, -0.002282403176650405, -0.002300382824614644, -0.002316814847290516, -0.0023316938895732164, -0.002345016226172447, -0.00235678069293499, -0.0023669868241995573, -0.002375636948272586, -0.002382733393460512, -0.002388281747698784, -0.0023922882974147797, -0.0023947618901729584, -0.0023957116063684225, -0.0023951490875333548, -0.0023930869065225124, -0.0023895397316664457, -0.0023845231626182795, -0.0023780546616762877, -0.0023701523896306753, -0.0023608366027474403, -0.002350128721445799, -0.0023380510974675417, -0.002324627945199609, -0.0023098839446902275, -0.0022938456386327744, -0.0022765405010432005, -0.0022579964715987444, -0.0022382440511137247, -0.002217313041910529, -0.0021952351089566946, -0.0021720430813729763, -0.0021477702539414167, -0.0021224503871053457, -0.0020961188711225986, -0.0020688113290816545, -0.0020405640825629234, -0.00201141438446939, -0.0019814001861959696, -0.0019505593227222562, -0.0019189307931810617, -0.0018865537131205201, -0.001853468012996018, -0.00181971350684762, -0.0017853305907920003, -0.0017503600101917982, -0.0017148427432402968, -0.0016788194188848138, -0.001642331713810563, -0.0016054208390414715, -0.0015681280056014657, -0.0015304946573451161, -0.0014925620052963495, -0.0014543712604790926, -0.001415963633917272, -0.0013773798709735274, -0.0013386609498411417, -0.0012998468009755015, -0.0012609778204932809, -0.0012220938224345446, -0.0011832340387627482, -0.0011444377014413476, -0.0011057429946959019, -0.0010671879863366485, -0.0010288102785125375, -0.0009906466584652662, -0.0009527335059829056, -0.0009151063277386129, -0.000877800106536597, -0.0008408492431044579, -0.0008042871486395597, -0.0007681464776396751, -0.0007324593607336283, -0.0006972569390200078, -0.000662569422274828, -0.0006284263217821717, -0.0005948561010882258, -0.0005618863506242633, -0.0005295437294989824, -0.0004978540237061679, -0.0004668418550863862, -0.00043653108878061175, -0.000406944309361279, -0.0003781032864935696, -0.00035002868389710784, -0.0003227400011382997, -0.00029625592287629843, -0.0002705937949940562, -0.0002457700320519507, -0.00022179986990522593, -0.0001986975985346362, -0.00017647621280048043, -0.00015514773258473724, -0.00013472304271999747, -0.00011521190754137933, -9.662298543844372e-05, -7.8963850683067e-05, -6.224095704965293e-05, -4.6459641453111544e-05, -3.162418579449877e-05, -1.77377623913344e-05, -4.80246990264277e-06, 7.18066667104722e-06, 1.821168370952364e-05, 2.8291666239965707e-05, 3.742273838724941e-05, 4.560805973596871e-05, 5.2851781219942495e-05, 5.915906513109803e-05, 6.453604873968288e-05, 6.898985157022253e-05, 7.252850627992302e-05, 7.516102050431073e-05, 7.689724588999525e-05, 7.774798723403364e-05, 7.772487151669338e-05, 7.684040610911325e-05, 7.510787690989673e-05, 7.25414211046882e-05, 6.915591075085104e-05, 6.496697460534051e-05, 5.999099084874615e-05, 5.424502523965202e-05, 4.774680201080628e-05, 4.051471478305757e-05, 3.256775380577892e-05, 2.3925524146761745e-05, 1.460818384657614e-05, 4.636424364434788e-06, -5.968548521195771e-06, -1.7185058823088184e-05, -2.8990974897169508e-05, -4.1363757190993056e-05, -5.4280459153233096e-05, -6.771778862457722e-05, -8.165212057065219e-05, -9.605952800484374e-05, -0.00011091581109212711, -0.00012619653716683388, -0.0001418770698364824, -0.0001579325762577355, -0.0001743380562402308, -0.0001910684659378603, -0.0002080985577777028, -0.00022540311329066753, -0.0002429568558000028, -0.00026073449407704175, -0.0002787107659969479, -0.00029686043853871524, -0.0003151584242004901, -0.0003335796936880797, -0.00035209936322644353, -0.0003706926654558629, -0.00038933512405492365, -0.00040800237911753356, -0.00042667039087973535, -0.0004453152942005545, -0.00046391363139264286, -0.0004824420902878046, -0.0005008779116906226, -0.00051919836550951, -0.0005373815656639636, -0.0005554055678658187, -0.0005732491263188422, -0.0005908913444727659, -0.0006083117914386094, -0.0006254905019886792, -0.0006424079183489084, -0.000659045297652483, -0.0006753841298632324, -0.0006914065452292562, -0.0007070951396599412, -0.0007224332657642663, -0.0007374047418124974, -0.0007519939099438488, -0.0007661859854124486, -0.0007799664163030684, -0.0007933216402307153, -0.0008062385022640228, -0.0008187045459635556, -0.0008307080715894699, -0.0008422378450632095, -0.0008532834472134709, -0.0008638350991532207, -0.0008738836622796953, -0.0008834206964820623, -0.0008924382855184376, -0.0009009296190924942, -0.0009088880615308881, -0.0009163079084828496, -0.0009231841540895402, -0.0009295124327763915, -0.0009352888446301222, -0.0009405106538906693, -0.000945175183005631, -0.0009492810349911451, -0.0009528268710710108, -0.0009558125166222453, -0.0009582380880601704, -0.0009601045749150217, -0.000961413374170661, -0.0009621666977182031, -0.0009623672813177109, -0.0009620185010135174, -0.0009611241985112429, -0.0009596890304237604, -0.0009577178861945868, -0.0009552165865898132, -0.0009521911852061749, -0.0009486486669629812, -0.0009445959003642201, -0.0009400408016517758, -0.0009349916945211589, -0.0009294571354985237, -0.0009234463213942945, -0.0009169687982648611, -0.0009100346942432225, -0.0009026543120853603, -0.0008948387112468481, -0.0008865988347679377, -0.0008779463241808116, -0.0008688931702636182, -0.0008594516548328102, -0.0008496341179125011, -0.0008394534816034138, -0.0008289228426292539, -0.0008180555887520313, -0.000806865282356739, -0.0007953657186590135, -0.0007835709839127958, -0.000771495106164366, -0.0007591524627059698, -0.0007465576636604965, -0.0007337252609431744, -0.0007206698064692318, -0.0007074063178151846, -0.0006939496379345655, -0.0006803146097809076, -0.0006665163091383874, -0.000652569520752877, -0.0006384894368238747, -0.0006242909003049135, -0.0006099888705648482, -0.0005955981905572116, -0.0005811336450278759, -0.0005666100769303739, -0.0005520419217646122, -0.000537443847861141, -0.0005228301743045449, -0.000508215045556426, -0.0004936125478707254, -0.000479036767501384, -0.00046450115041807294, -0.0004500193172134459, -0.0004356044519226998, -0.00042126973858103156, -0.00040702789556235075, -0.00039289146661758423, -0.00037887279177084565, -0.0003649838618002832, -0.00035123637644574046, -0.0003376418026164174, -0.0003242112579755485, -0.0003109555400442332, -0.00029788509709760547, -0.0002850101445801556, -0.0002723404613789171, -0.0002598855353426188, -0.00024765441776253283, -0.00023565589799545705, -0.0002238983433926478, -0.00021238978661131114, -0.00020113782375119627, -0.00019014973076991737, -0.0001794324052752927, -0.00016899227921385318, -0.00015883546438999474, -0.0001489676651544869, -0.00013939417840447277, -0.00013011993723921478, -0.00012114943092456087, -0.00011248677765252069, -0.00010413570271339267, -9.609954577172175e-05, -8.838120993459597e-05, -8.09832417871803e-05, -7.390778773697093e-05, -6.71566158416681e-05, -6.073108306736685e-05, -5.463218622026034e-05, -4.8860532842809334e-05, -4.34163557656575e-05, -3.829952038358897e-05, -3.3509528293507174e-05, -2.9045513656456023e-05, -2.490626684448216e-05, -2.109021988871973e-05, -1.759547012625262e-05, -1.4419769286178052e-05, -1.1560552593437023e-05, -9.014923307404388e-06, -6.7796763687510975e-06, -4.851298854191555e-06, -3.2259802082990063e-06, -1.8996200878973468e-06, -8.678364906700153e-07, -1.2597544696291152e-07, 3.308805389679037e-07, 5.079031666355149e-07, 4.1050910226658743e-07, 4.434991751622874e-08, -5.846970339007385e-07, -1.4705386774949147e-06, -2.6068764782394283e-06, -3.9872156776255e-06, -5.604877514997497e-06, -7.453005764546106e-06, -9.524582310405094e-06, -1.1812433513114229e-05, -1.430923930456629e-05, -1.7007550923153758e-05, -1.989979500649497e-05, -2.2978283595875837e-05, -2.623522959765978e-05, -2.9662754968740046e-05, -3.325289799249731e-05, -3.699762964970432e-05, -4.0888855437515303e-05, -4.491844811127521e-05, -4.9078214942710474e-05, -5.33599522896111e-05, -5.775543468189426e-05, -6.225642573554069e-05, -6.685467815259472e-05, -7.154198829084635e-05, -7.631012704223394e-05, -8.115093078231439e-05, -8.60562504385598e-05, -9.101800242206082e-05, -9.602814679965377e-05, -0.00010107870912179351, -0.00010616180225042626, -0.00011126959725515917, -0.0001163943816209212, -0.00012152851559221745, -0.00012666446855291724, -0.00013179484813008457, -0.0001369123492622748, -0.0001420098269591108, -0.00014708020898979157, -0.00015211662685032934, -0.0001571123139001429, -0.0001620607217773795, -0.00016695534577593207, -0.00017178995767608285, -0.00017655840201769024, -0.000181254799827002, -0.00018587334488984197, -0.00019040846382267773, -0.00019485477241687477, -0.0001992070465348661, -0.00020346028031781316, -0.00020760964252986014, -0.00021165053476579487, -0.00021557848958764225, -0.00021938934514764696, -0.00022307902690954506, -0.00022664375137537718, -0.00023007990967016667, -0.00023338412574958056, -0.0002365531981922686, -0.000239584143855609, -0.00024247421242762357, -0.0002452208718750626, -0.00024782170657999814, -0.000250274664722383, -0.00025257779634557664, -0.0002547293552197516, -0.00025672782794572413, -0.00025857199216261506, -0.0002602606837172061, -0.00026179305859841406, -0.00026316833100281656, -0.00026438606437295675, -0.00026544599677436054, -0.00026634795358404517, -0.000267092022113502, -0.0002676785225048661, -0.00026810786221176386, -0.00026838071062229574, -0.00026849782443605363, -0.000268460251390934, -0.00026826909743249416, -0.0002679256722331047, -0.0002674315182957798, -0.00026678823633119464, -0.0002659976598806679, -0.0002650616515893489, -0.0002639823069330305, -0.0002627618669066578, -0.00026140271802432835, -0.00025990727590397, -0.00025827818899415433, -0.0002565181930549443, -0.0002546301402617246, -0.0002526169118937105, -0.0002504815929569304, -0.0002482273557689041, -0.00024585743085481226, -0.000243375136051327, -0.00024078394926618785, -0.00023808726109564304, -0.00023528870951849967, -0.00023239190340973437, -0.00022940053895581514, -0.00022631835599895567, -0.0002231491671409458, -0.00021989678498357534, -0.00021656510944012552, -0.00021315811318345368, -0.00020967965247109532, -0.00020613377273548394, -0.00020252444664947689, -0.00019885567598976195, -0.0001951314916368574, -0.0001913559390231967, -0.0001875329908216372, -0.0001836667361203581, -0.00017976114759221673, -0.00017582022701390088, -0.00017184799071401358, -0.00016784838226158172, -0.00016382533067371696, -0.0001597827795194462, -0.00015572455595247447, -0.000151654559886083, -0.0001475765457144007, -0.00014349428238347173, -0.00013941146607976407, -0.0001353317784378305, -0.00013125877012498677, -0.00012719603546429425, -0.00012314703781157732, -0.00011911520414287224, -0.00011510388139868155, -0.00011111635103588924, -0.00010715582902776077, -0.00010322547313990071, -9.932833927450702e-05, -9.546741785015911e-05, -9.164562652586028e-05, -8.78657738212496e-05, -8.41306391521357e-05, -8.04428564151749e-05, -7.680501585127786e-05, -7.321961311390623e-05, -6.96890419931151e-05, -6.621562351938337e-05, -6.280159141169861e-05, -5.944906297372654e-05, -5.616008638753556e-05, -5.293662252370268e-05, -4.978052311344072e-05, -4.669355621444993e-05, -4.3677409848896787e-05, -4.073364834766835e-05, -3.786378147196956e-05, -3.506920256768353e-05, -3.2351217669202015e-05, -2.9711038223467767e-05, -2.7149793822900392e-05, -2.466852129145991e-05, -2.2268161046667956e-05, -1.9949569832533598e-05, -1.771351344359573e-05, -1.5560670362901874e-05, -1.3491639947460499e-05, -1.1506924238346983e-05, -9.60694615059765e-06, -7.792049473209772e-06, -6.062489319447195e-06, -4.41844576926087e-06, -2.86001500171551e-06, -1.3872183899366064e-06, -8.446716050994029e-20, 1.3017710216445266e-06, 2.5182989702443592e-06, 3.649859763754648e-06, 4.696799805969931e-06, 5.6595326896058396e-06, 6.538541128975339e-06, 7.334370820899494e-06, 8.047632036323193e-06, 8.678995982336346e-06, 9.229192983184475e-06, 9.699014299258124e-06, 1.008930576062994e-05, 1.0400964129075874e-05, 1.0634946193022188e-05, 1.0792251487146132e-05, 1.0873936844291165e-05, 1.0881099115067627e-05, 1.0814884262799751e-05, 1.067647917807335e-05, 1.0467118954693433e-05, 1.0188069609284867e-05, 9.840641723712906e-06, 9.426180440641474e-06, 8.94606546353316e-06, 8.401711966143921e-06, 7.794561497576069e-06, 7.12608971298323e-06, 6.397799097612733e-06, 5.611218057310907e-06, 4.767900009028381e-06, 3.869422471325379e-06, 2.9173829716455657e-06, 1.9134010926791234e-06, 8.591140385760809e-07, -2.438232513668481e-07, -1.393740035382507e-06, -2.5889512471621856e-06, -3.827758519037161e-06, -5.108450750412885e-06, -6.429308541555656e-06, -7.78860066930065e-06, -9.184589544020128e-06, -1.061553030012874e-05, -1.207967125083087e-05, -1.3575258890341502e-05, -1.5100532436918002e-05, -1.665373201831244e-05, -1.8233091395813972e-05, -1.983685069717467e-05, -2.146324550267309e-05, -2.3110515030566603e-05, -2.4776898499112576e-05, -2.6460644221515395e-05, -2.815999323502183e-05, -2.987320658576209e-05, -3.1598538043908775e-05, -3.3334250474581495e-05, -3.507862129481509e-05, -3.6829929740633816e-05, -3.8586458686040714e-05, -4.034651647089049e-05, -4.210840415908024e-05, -4.387044100440107e-05, -4.5630957174580544e-05, -4.7388297389261425e-05, -4.914080273010768e-05, -5.088686157250777e-05, -5.2624844101956114e-05, -5.435314233181998e-05, -5.607017010333948e-05, -5.7774352171691135e-05, -5.94641242059879e-05]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[-3.54692674591206e-05, -1.5961430108291097e-05, 1.1423881915106904e-05, 3.8869009586051106e-05, 5.85156049055513e-05, 6.456949631683528e-05, 5.485889414558187e-05, 3.142736022709869e-05, -4.676419270954239e-18, -3.1537732866127044e-05, -5.524489461095072e-05, -6.525212666019797e-05, -5.934182263445109e-05, -3.95561582990922e-05, -1.1666620594041888e-05, 1.6357738786609843e-05, 3.6477325920714065e-05, 4.273735248716548e-05, 3.287445360911079e-05, 8.941697160480544e-06, -2.3220116418087855e-05, -5.552899165195413e-05, -7.981700036907569e-05, -9.002008300740272e-05, -8.381575753446668e-05, -6.326693983282894e-05, -3.429358548601158e-05, -5.106929165776819e-06, 1.5980192983988672e-05, 2.278385181853082e-05, 1.2922615496790968e-05, -1.1517996426846366e-05, -4.4515029003378004e-05, -7.769754301989451e-05, -0.00010257703979732469, -0.00011282508057774976, -0.0001059876085491851, -8.417192293563858e-05, -5.351450454327278e-05, -2.2563262973562814e-05, 1.6709011150443594e-18, 7.690937309234869e-06, -2.0174720702925697e-06, -2.698341995710507e-05, -6.093269257689826e-05, -9.510938980383798e-05, -0.00012060716835549101, -0.00013076094910502434, -0.00012295735359657556, -9.937275171978399e-05, -6.643097003689036e-05, -3.3114854886662215e-05, -8.574659659643658e-06, 3.3077833450079197e-07, -9.099763701669872e-06, -3.464342080405913e-05, -6.970295362407342e-05, -0.00010503781231818721, -0.00013122284144628793, -0.0001411812991136685, -0.00013211181794758886, -0.00010628556628944352, -7.048727275105193e-05, -3.4236789360875264e-05, -7.256151548062917e-06, 3.144430593238212e-06, -5.940158189332578e-06, -3.218027632101439e-05, -6.858119741082191e-05, -0.00010531422594795004, -0.00013233069330453873, -0.00014206438208930194, -0.00013149625738151371, -0.00010301895235897973, -6.3854553445708e-05, -2.416573988739401e-05, 5.646464160236064e-06, 1.7740776456776075e-05, 8.977442121249624e-06, -1.8180402548750862e-05, -5.626324127661064e-05, -9.474693797528744e-05, -0.00012285070260986686, -0.00013243811554275453, -0.00012024173338431865, -8.880333916749805e-05, -4.5861484977649525e-05, -2.3314789814321557e-06, 3.0595714633818716e-05, 4.446518141776323e-05, 3.587075480027124e-05, 7.436885880451882e-06, -3.281193130533211e-05, -7.354480476351455e-05, -0.00010313616076018661, -0.00011279583122814074, -9.897581185214221e-05, -6.439574644900858e-05, -1.7392614608979784e-05, 3.025218211405445e-05, 6.644282984780148e-05, 8.202542085200548e-05, 7.329467189265415e-05, 4.306529081077315e-05, -1.3635019810607187e-18, -4.364813139545731e-05, -7.529193680966273e-05, -8.540068665752187e-05, -7.011265552137047e-05, -3.235478652641177e-05, 1.8852881112252362e-05, 7.074540917528793e-05, 0.0001102033638744615, 0.00012728574802167714, 0.00011795444879680872, 8.524466102244332e-05, 3.854370515909977e-05, -8.853469807945658e-06, -4.327703209128231e-05, -5.43656678928528e-05, -3.790931077674031e-05, 2.9274508506205166e-06, 5.835404954268597e-05, 0.00011450071906438097, 0.0001571017928654328, 0.00017533815116621554, 0.00016480422345921397, 0.00012878721463494003, 7.748867210466415e-05, 2.5369468858116306e-05, -1.2692377822531853e-05, -2.541166395531036e-05, -8.193968824343756e-06, 3.552726047928445e-05, 9.510067320661619e-05, 0.00015542640176136047, 0.00020096584921702743, 0.00021992780966684222, 0.0002075037482427433, 0.000167265665368177, 0.00011032214388251305, 5.242860788712278e-05, 9.801218766369857e-06, -5.254237748886226e-06, 1.2278390386200044e-05, 5.866468927706592e-05, 0.00012229930143803358, 0.00018672282749321312, 0.00023499289818573743, 0.0002542492584325373, 0.00023924370179884136, 0.0001938670320669189, 0.00013023120118305087, 6.551911064889282e-05, 1.7419602954760194e-05, -6.408894819287525e-07, 1.681425237620715e-05, 6.571647827513516e-05, 0.00013341013982426375, 0.00020194248645566404, 0.00025283204740844667, 0.00027204930665902793, 0.00025386858033016324, 0.00020253470574971288, 0.0001312623789999634, 5.879953459952958e-05, 4.4467665247793775e-06, -1.714543395792134e-05, 2.2895790668796676e-18, 5.1446055294945836e-05, 0.00012338704254943877, 0.00019623854313977063, 0.00024984002811834216, 0.0002688889508135617, 0.00024714283063076437, 0.00018923680181615055, 0.00010959102655760944, 2.866055910999421e-05, -3.2498737709829584e-05, -5.790556679130532e-05, -4.104126855963841e-05, 1.3252943972474895e-05, 8.99180886335671e-05, 0.0001675947569310665, 0.00022429833188652992, 0.00024334577028639615, 0.00021793691848870367, 0.00015313444600906223, 6.466983904829249e-05, -2.5148261556751095e-05, -9.336052607977763e-05, -0.00012254485045559704, -0.00010559877409832552, -4.7804984205868095e-05, 3.441711305640638e-05, 0.00011778450425481424, 0.0001783383486326784, 0.00019790345686487854, 0.00016907929966691881, 9.739420056575909e-05, -2.683390657529426e-18, -9.878996934276074e-05, -0.0001739601866574958, -0.0002065343433059752, -0.00018878302944358438, -0.00012646932736970484, -3.748434755834751e-05, 5.281127232592553e-05, 0.00011832858581328765, 0.0001392844133079052, 0.00010763327736640349, 2.9408049158519134e-05, -7.670683407923207e-05, -0.0001842375349951908, -0.0002659548190422356, -0.00030121137388050556, -0.0002816066553350538, -0.00021342492254916579, -0.00011614436516538262, -1.736313606670592e-05, 5.4538057156605646e-05, 7.804777123965323e-05, 4.4428954424802214e-05, -3.974126229877584e-05, -0.00015413005894515663, -0.0002699423930607736, -0.00035757277510128915, -0.00039458266110159457, -0.00037185463588684797, -0.0002962368307635188, -0.00018891443323809654, -7.988878496689722e-05, 5.498497006308427e-18, 2.7387335649109446e-05, -7.204018857009942e-06, -9.661185322329402e-05, -0.00021873562945984304, -0.00034229306038469076, -0.0004351343959569931, -0.00047290537622757256, -0.0004457252216525376, -0.0003610500134527683, -0.0002418962394585833, -0.00012084013724233955, -3.135499719064683e-05, 1.2119937764509814e-06, -3.340712282806635e-05, -0.00012742301623802632, -0.0002568438649177551, -0.0003877284179907292, -0.00048520881682634354, -0.0005228864029049873, -0.0004900683998130262, -0.0003948647063225508, -0.0002622516476549208, -0.0001275583344977349, -2.7071080694440752e-05, 1.1746270502044354e-05, -2.2217256628209725e-05, -0.00012050154327880591, -0.0002570955257397145, -0.000395220733480528, -0.0004971110611222684, -0.0005341893411241472, -0.0004949007416144013, -0.0003880558942910284, -0.0002407240535831079, -9.11709648789838e-05, 2.1317706341505982e-05, 6.702285463688895e-05, 3.393661609152332e-05, -6.876453699078411e-05, -0.00021291719167493284, -0.00035872054286301136, -0.0004653225187212229, -0.0005018288502469659, -0.0004557691572699696, -0.0003367032913956791, -0.00017393067537341267, -8.844051990308799e-06, 0.00011607917986111715, 0.00016872136620804667, 0.00013612238399218768, 2.8222922992426902e-05, -0.00012452249939087778, -0.0002790980215650052, -0.00039137061685323715, -0.0004279832646716386, -0.00037549459375441074, -0.0002442627737764269, -6.595918239327148e-05, 0.00011469975288491696, 0.0002518457768019289, 0.0003108146775048226, 0.0002776372421067208, 0.00016306892212014645, -3.8706667721693975e-18, -0.00016513759328518063, -0.00028472606209106743, -0.00032279419247061014, -0.00026487058494240046, -0.00012216207687743008, 7.11416796548292e-05, 0.0002667971421033144, 0.0004153390182182193, 0.00047940341755747795, 0.0004439539334271103, 0.00032061367528513074, 0.00014486012514680624, -3.324902354506776e-05, -0.00016239866090472788, -0.00020384464005474, -0.00014202346210367978, 1.0958061466226354e-05, 0.00021824064606335014, 0.0004278426058590412, 0.0005864880513399839, 0.0006539546884596348, 0.0006140790064819157, 0.0004794074920937419, 0.00028816290432587266, 9.424774907529354e-05, -4.710363646154292e-05, -9.420819696970284e-05, -3.0344954211614095e-05, 0.00013142655370756984, 0.00035142048727720976, 0.0005736980237998068, 0.0007409501704387367, 0.0008099317783489823, 0.0007632895722053945, 0.0006145522929728031, 0.0004048529954161495, 0.0001921673392644152, 3.5880795621778816e-05, -1.9211298422305845e-05, 4.483817974687554e-05, 0.0002139623829862103, 0.00044548549340106547, 0.0006792831118218601, 0.0008537820540368557, 0.0009225416579283774, 0.0008669544477015734, 0.0007015920709818602, 0.0004706697363872081, 0.00023647515627089888, 6.278674118220806e-05, -2.306859187228838e-06, 6.0439357184804976e-05, 0.0002358942001592368, 0.0004782211617566645, 0.0007228716858662665, 0.0009037656709551811, 0.0009710874292068183, 0.0009049061336554587, 0.00072089972672984, 0.000466545025119558, 0.00020869035506621003, 1.5759604139020666e-05, -6.067633876227774e-05, 7.115355516802553e-18, 0.00018153298879042268, 0.000434746325481683, 0.0006904168985784054, 0.0008777034236118197, 0.0009432252263650298, 0.0008656559512019157, 0.0006618445622734725, 0.000382716185413301, 9.993930143537e-05, -0.00011315311712678522, -0.00020131090423092246, -0.0001424666988896206, 4.593559424392879e-05, 0.0003111912519671023, 0.0005791390431113541, 0.000773908628616482, 0.0008383546373806894, 0.000749677128624171, 0.0005259629106149077, 0.00022177983191795647, -8.611240627942607e-05, -0.0003191963769495487, -0.00041833691648207605, -0.00035993667552247643, -0.00016269573825411499, 0.00011695343710016459, 0.00039963365998119116, 0.0006041626911610365, 0.0006694185431115329, 0.0005710445111617446, 0.00032843390363268554, -2.5175802771506708e-17, -0.00033212287235073745, -0.0005839445511810482, -0.0006922297761775553, -0.0006317677907645702, -0.0004225876182317734, -0.00012506016355473548, 0.0001759274600772187, 0.0003935820423066616, 0.00046258053043857217, 0.000356920383637771, 9.737145592225716e-05, -0.0002535951789468527, -0.0006081733736209571, -0.0008765975944697857, -0.0009913065005093813, -0.0009253896423615515, -0.0007002820493653417, -0.00038051625597290695, -5.6800421589287e-05, 0.00017814457532949746, 0.00025455644936300814, 0.00014469104644376785, -0.00012923209578730166, -0.0005004614940844476, -0.0008752061403356493, -0.0011576066026464105, -0.001275537651963532, -0.0012002969160676003, -0.0009548084926791489, -0.0006080028833821416, -0.0002567386254668236, 6.401356373103931e-18, 8.775861351750791e-05, -2.3050728486850858e-05, -0.0003086823271587491, -0.0006978694000281394, -0.0010905055096372962, -0.0013842994812875986, -0.0015023102751001716, -0.0014139473205432296, -0.0011437099892646074, -0.0007651773630641401, -0.00038170741754584014, -9.890418004943058e-05, 3.81767267754185e-06, -0.00010508236300665885, -0.00040025170892477036, -0.0008056588703766465, -0.0012145303189754486, -0.0015177855966612697, -0.0016333985840901732, -0.0015287866117432714, -0.0012301160022616386, -0.000815879087895155, -0.0003963040071539581, -8.399232319789007e-05, 3.6395755159901455e-05, -6.874802056699991e-05, -0.0003723778063431382, -0.0007934316527098417, -0.001218094490468502, -0.0015301121165975928, -0.0016420872416347265, -0.0015193319413810968, -0.0011897752992808819, -0.0007371039246208966, -0.0002788091078400612, 6.510801904369146e-05, 0.00020443875109776855, 0.00010338503489037976, -0.00020922093244735152, -0.0006470017251558602, -0.0010886986274272203, -0.0014104736037552357, -0.001519247773103416, -0.0013781064189970493, -0.0010168402222916484, -0.0005246283835731447, -2.664402563823387e-05, 0.00034928403329104185, 0.0005070759216323495, 0.0004086146072950214, 8.461952529614791e-05, -0.0003729095042217523, -0.0008348380797542632, -0.0011693013366311789, -0.0012772053014487028, -0.0011192731326445937, -0.0007272624643519521, -0.00019616138888522983, 0.000340728263836354, 0.000747292535379529, 0.0009212356526404619, 0.0008219839073717594, 0.00048225425416603684, -7.62292594837428e-18, -0.00048730228445492685, -0.00083928246749565, -0.0009504693443886936, -0.0007790775271132588, -0.00035893928725272417, 0.00020880911324638873, 0.0007822586339898407, 0.0012165190419182181, 0.0014027084689587355, 0.0012976499274373055, 0.0009361775009892881, 0.0004225563898216933, -9.688969294074923e-05, -0.00047276716213673353, -0.0005928344908170402, -0.0004126357671339065, 3.1806535844225436e-05, 0.0006328450399450958, 0.001239447738043964, 0.0016974189784377813, 0.0018908914644271135, 0.0017739261966198683, 0.0013836038997396827, 0.0008308910182677209, 0.00027150599635206163, -0.000135571594000794, -0.0002709019463509321, -8.718114258954301e-05, 0.0003772552008740604, 0.001007856335490942, 0.0016439090250059962, 0.002121338155120611, 0.00231685652397573, 0.0021815914660692215, 0.001755010918714106, 0.0011552039068192244, 0.0005478792008943856, 0.00010221502452623099, -5.4684027418261394e-05, 0.0001275282265851274, 0.0006080704624764621, 0.001265062252059579, 0.0019275008235126734, 0.0024208046961575747, 0.002613794757053256, 0.002454472007229924, 0.001984844682738185, 0.001330582657828927, 0.0006680339574813843, 0.0001772442483343184, -6.507590114779305e-06, 0.00017037958605214953, 0.000664534280076623, 0.0013462791685014963, 0.0020336564630270004, 0.0025408908259123564, 0.0027283879462629557, 0.002540813758969307, 0.0020228771027177572, 0.0013083305675536394, 0.0005848700529895723, 4.414071372593753e-05, -0.0001698456471785903, 1.7176656882569836e-17, 0.000507556542288512, 0.0012148357927799225, 0.001928190584294498, 0.002449893392622471, 0.00263135670684278, 0.0024136740248650312, 0.0018444304587319493, 0.0010660074185580015, 0.00027822807896882296, -0.0003148592950310558, -0.0005598951829597354, -0.00039604678750038147, 0.00012763807899318635, 0.0008642916800454259, 0.0016077631153166294, 0.0021475309040397406, 0.0023253709077835083, 0.0020785368978977203, 0.001457679201848805, 0.0006144075887277722, -0.00023846914700698107, -0.0008836104534566402, -0.0011576301185414195, -0.0009956688154488802, -0.00044989850721322, 0.000323299813317135, 0.0011043661506846547, 0.0016690443735569715, 0.001848754589445889, 0.0015766075812280178, 0.0009065218619070947, -1.068486402591487e-17, -0.0009162125643342733, -0.0016104958485811949, -0.0019086813554167747, -0.001741568325087428, -0.0011646740604192019, -0.0003446005575824529, 0.0004846685042139143, 0.0010840900940820575, 0.001273917150683701, 0.0009827743051573634, 0.0002680696197785437, -0.0006980641046538949, -0.0016738827107474208, -0.0024123829789459705, -0.002727766986936331, -0.0025461395271122456, -0.0019266105955466628, -0.0010467974934726954, -0.00015624804655089974, 0.0004900205531157553, 0.0007001801277510822, 0.0003979755856562406, -0.00035545090213418007, -0.0013765105977654457, -0.0024072665255516768, -0.0031840885058045387, -0.0035085941199213266, -0.0033017918467521667, -0.0026266600470989943, -0.0016727279871702194, -0.000706396356690675, 1.4001335504105377e-17, 0.00024151209800038487, -6.344365829136223e-05, -0.0008497191593050957, -0.0019213370978832245, -0.0030028163455426693, -0.003812487004324794, -0.00413829181343317, -0.0038956841453909874, -0.0031518202740699053, -0.002109155524522066, -0.001052407780662179, -0.000272760255029425, 1.0531354746490251e-05, -0.00028996169567108154, -0.0011047790758311749, -0.002224493306130171, -0.003354534739628434, -0.004193576984107494, -0.004514639265835285, -0.004227083642035723, -0.003402589587494731, -0.002257696120068431, -0.0010971116134896874, -0.00023262226022779942, 0.00010084594396175817, -0.00019057707686442882, -0.0010327704949304461, -0.002201638650149107, -0.0033817442599684, -0.004250239580869675, -0.0045637693256139755, -0.004224978853017092, -0.003310460364446044, -0.0020521588157862425, -0.0007767034694552422, 0.00018149147217627615, 0.0005702505586668849, 0.0002885681751649827, -0.0005843751132488251, -0.0018084037583321333, -0.003045150311663747, -0.003948069643229246, -0.004255739971995354, -0.0038633469957858324, -0.0028528315015137196, -0.001473077805712819, -7.487423863494769e-05, 0.0009823766304180026, 0.0014274056302383542, 0.0011512550991028547, 0.00023862729722168297, -0.0010525755351409316, -0.0023586363531649113, -0.003306760685518384, -0.0036154582630842924, -0.003171567339450121, -0.00206287601031363, -0.0005569916102103889, 0.0009685131954029202, 0.0021264711394906044, 0.0026243417523801327, 0.002344245556741953, 0.0013769416837021708, -1.0895332688153474e-17, -0.0013946533435955644, -0.002404942875728011, -0.0027269269339740276, -0.002238024491816759, -0.001032438245601952, 0.0006013975944370031, 0.002256015781313181, 0.003513182047754526, 0.004056484438478947, 0.003757952246814966, 0.002715026494115591, 0.001227251603268087, -0.0002818193461280316, -0.0013771966332569718, -0.0017296128207817674, -0.00120575912296772, 9.30893438635394e-05, 0.0018551655812188983, 0.0036393774207681417, 0.004992447793483734, 0.005570944864302874, 0.005235377233475447, 0.004090598784387112, 0.0024609032552689314, 0.000805597344879061, -0.00040300312684848905, -0.0008068003808148205, -0.00026013815659098327, 0.001127866911701858, 0.0030190893448889256, 0.004934279248118401, 0.006380259525030851, 0.006982717197388411, 0.006588853895664215, 0.005311804823577404, 0.003503979416564107, 0.0016654946375638247, 0.00031141817453317344, -0.00016698440595064312, 0.00039032247150316834, 0.001865472411736846, 0.00389027688652277, 0.005941734649240971, 0.00748074846342206, 0.008097297511994839, 0.007623021490871906, 0.0061803520657122135, 0.004153973422944546, 0.00209109322167933, 0.000556311453692615, -2.048119858955033e-05, 0.0005377256311476231, 0.00210323347710073, 0.004273179918527603, 0.006473798770457506, 0.008112466894090176, 0.008737326599657536, 0.008161520585417747, 0.006518000736832619, 0.004228925798088312, 0.001896536210551858, 0.00014359920169226825, -0.0005543705774471164, 1.6297385398121894e-17, 0.0016678781248629093, 0.004005892667919397, 0.006380536127835512, 0.008135870099067688, 0.008770223706960678, 0.008074368350207806, 0.006193223409354687, 0.003593064146116376, 0.0009414175292477012, -0.0010695502860471606, -0.0019095108145847917, -0.0013561892556026578, 0.0004388749657664448, 0.0029842578805983067, 0.005574976559728384, 0.007478857412934303, 0.008133798837661743, 0.007302899844944477, 0.00514479074627161, 0.0021785262506455183, -0.0008495165966451168, -0.0031627698335796595, -0.004163686651736498, -0.00359881529584527, -0.001634298707358539, 0.0011804047971963882, 0.004053074400871992, 0.006157769821584225, 0.006857371889054775, 0.0058798291720449924, 0.0033995588310062885, -1.3431878727824884e-17, -0.0034751405473798513, -0.0061442130245268345, -0.007325123064219952, -0.006724225822836161, -0.004524524323642254, -0.0013470965204760432, 0.0019067353568971157, 0.004292632918804884, 0.005077656824141741, 0.0039435927756130695, 0.0010830675018951297, -0.0028400628361850977, -0.006858649663627148, -0.009956314228475094, -0.01134116668254137, -0.010665754787623882, -0.008132511749863625, -0.004453269764780998, -0.0006700116791762412, 0.002118367236107588, 0.003052006708458066, 0.001749413670040667, -0.0015759763773530722, -0.006156861782073975, -0.01086405199021101, -0.014501767233014107, -0.01612945832312107, -0.015324012376368046, -0.012309794314205647, -0.00791748147457838, -0.0033776815980672836, 1.7457142247757992e-17, 0.001179286278784275, -0.0003131674893666059, -0.004241102375090122, -0.00969911552965641, -0.01533545833081007, -0.019703077152371407, -0.0216484647244215, -0.02063465304672718, -0.016908852383494377, -0.011464033275842667, -0.005797372665256262, -0.0015233311569318175, 5.965094533166848e-05, -0.0016663017449900508, -0.00644369563087821, -0.013173803687095642, -0.02017967589199543, -0.02563644014298916, -0.02805985137820244, -0.02672388218343258, -0.02189180999994278, -0.014790346845984459, -0.007322227582335472, -0.0015826101880520582, 0.0006998020107857883, -0.0013497689506039023, -0.0074706352315843105, -0.01627698913216591, -0.025572337210178375, -0.0328996479511261, -0.0361923985183239, -0.034357763826847076, -0.027631936594843864, -0.017599496990442276, -0.006851492915302515, 0.001648675068281591, 0.005341202486306429, 0.0027906394097954035, -0.005843364633619785, -0.018727043643593788, -0.03271378204226494, -0.0440826453268528, -0.04948890209197998, -0.0468946173787117, -0.03623595088720322, -0.01963309571146965, -0.001050335238687694, 0.014554648660123348, 0.02242277003824711, 0.019260002300143242, 0.004273258615285158, -0.020296171307563782, -0.04931282624602318, -0.07558463513851166, -0.09125999361276627, -0.08950801193714142, -0.06612426042556763, -0.020700471475720406, 0.042924437671899796, 0.1170695424079895, 0.1914290189743042, 0.25487950444221497, 0.29752206802368164, 0.3125448226928711, 0.29752206802368164, 0.25487950444221497, 0.1914290189743042, 0.1170695424079895, 0.042924437671899796, -0.020700471475720406, -0.06612426042556763, -0.08950801193714142, -0.09125999361276627, -0.07558463513851166, -0.04931282624602318, -0.020296171307563782, 0.004273258615285158, 0.019260002300143242, 0.02242277003824711, 0.014554648660123348, -0.001050335238687694, -0.01963309571146965, -0.03623595088720322, -0.0468946173787117, -0.04948890209197998, -0.0440826453268528, -0.03271378204226494, -0.018727043643593788, -0.005843364633619785, 0.0027906394097954035, 0.005341202486306429, 0.001648675068281591, -0.006851492915302515, -0.017599496990442276, -0.027631936594843864, -0.034357763826847076, -0.0361923985183239, -0.0328996479511261, -0.025572337210178375, -0.01627698913216591, -0.0074706352315843105, -0.0013497689506039023, 0.0006998020107857883, -0.0015826101880520582, -0.007322227582335472, -0.014790346845984459, -0.02189180999994278, -0.02672388218343258, -0.02805985137820244, -0.02563644014298916, -0.02017967589199543, -0.013173803687095642, -0.00644369563087821, -0.0016663017449900508, 5.965094533166848e-05, -0.0015233311569318175, -0.005797372665256262, -0.011464033275842667, -0.016908852383494377, -0.02063465304672718, -0.0216484647244215, -0.019703077152371407, -0.01533545833081007, -0.00969911552965641, -0.004241102375090122, -0.0003131674893666059, 0.001179286278784275, 1.7457142247757992e-17, -0.0033776815980672836, -0.00791748147457838, -0.012309794314205647, -0.015324012376368046, -0.01612945832312107, -0.014501767233014107, -0.01086405199021101, -0.006156861782073975, -0.0015759763773530722, 0.001749413670040667, 0.003052006708458066, 0.002118367236107588, -0.0006700116791762412, -0.004453269764780998, -0.008132511749863625, -0.010665754787623882, -0.01134116668254137, -0.009956314228475094, -0.006858649663627148, -0.0028400628361850977, 0.0010830675018951297, 0.0039435927756130695, 0.005077656824141741, 0.004292632918804884, 0.0019067353568971157, -0.0013470965204760432, -0.004524524323642254, -0.006724225822836161, -0.007325123064219952, -0.0061442130245268345, -0.0034751405473798513, -1.3431878727824884e-17, 0.0033995588310062885, 0.0058798291720449924, 0.006857371889054775, 0.006157769821584225, 0.004053074400871992, 0.0011804047971963882, -0.001634298707358539, -0.00359881529584527, -0.004163686651736498, -0.0031627698335796595, -0.0008495165966451168, 0.0021785262506455183, 0.00514479074627161, 0.007302899844944477, 0.008133798837661743, 0.007478857412934303, 0.005574976559728384, 0.0029842578805983067, 0.0004388749657664448, -0.0013561892556026578, -0.0019095108145847917, -0.0010695502860471606, 0.0009414175292477012, 0.003593064146116376, 0.006193223409354687, 0.008074368350207806, 0.008770223706960678, 0.008135870099067688, 0.006380536127835512, 0.004005892667919397, 0.0016678781248629093, 1.6297385398121894e-17, -0.0005543705774471164, 0.00014359920169226825, 0.001896536210551858, 0.004228925798088312, 0.006518000736832619, 0.008161520585417747, 0.008737326599657536, 0.008112466894090176, 0.006473798770457506, 0.004273179918527603, 0.00210323347710073, 0.0005377256311476231, -2.048119858955033e-05, 0.000556311453692615, 0.00209109322167933, 0.004153973422944546, 0.0061803520657122135, 0.007623021490871906, 0.008097297511994839, 0.00748074846342206, 0.005941734649240971, 0.00389027688652277, 0.001865472411736846, 0.00039032247150316834, -0.00016698440595064312, 0.00031141817453317344, 0.0016654946375638247, 0.003503979416564107, 0.005311804823577404, 0.006588853895664215, 0.006982717197388411, 0.006380259525030851, 0.004934279248118401, 0.0030190893448889256, 0.001127866911701858, -0.00026013815659098327, -0.0008068003808148205, -0.00040300312684848905, 0.000805597344879061, 0.0024609032552689314, 0.004090598784387112, 0.005235377233475447, 0.005570944864302874, 0.004992447793483734, 0.0036393774207681417, 0.0018551655812188983, 9.30893438635394e-05, -0.00120575912296772, -0.0017296128207817674, -0.0013771966332569718, -0.0002818193461280316, 0.001227251603268087, 0.002715026494115591, 0.003757952246814966, 0.004056484438478947, 0.003513182047754526, 0.002256015781313181, 0.0006013975944370031, -0.001032438245601952, -0.002238024491816759, -0.0027269269339740276, -0.002404942875728011, -0.0013946533435955644, -1.0895332688153474e-17, 0.0013769416837021708, 0.002344245556741953, 0.0026243417523801327, 0.0021264711394906044, 0.0009685131954029202, -0.0005569916102103889, -0.00206287601031363, -0.003171567339450121, -0.0036154582630842924, -0.003306760685518384, -0.0023586363531649113, -0.0010525755351409316, 0.00023862729722168297, 0.0011512550991028547, 0.0014274056302383542, 0.0009823766304180026, -7.487423863494769e-05, -0.001473077805712819, -0.0028528315015137196, -0.0038633469957858324, -0.004255739971995354, -0.003948069643229246, -0.003045150311663747, -0.0018084037583321333, -0.0005843751132488251, 0.0002885681751649827, 0.0005702505586668849, 0.00018149147217627615, -0.0007767034694552422, -0.0020521588157862425, -0.003310460364446044, -0.004224978853017092, -0.0045637693256139755, -0.004250239580869675, -0.0033817442599684, -0.002201638650149107, -0.0010327704949304461, -0.00019057707686442882, 0.00010084594396175817, -0.00023262226022779942, -0.0010971116134896874, -0.002257696120068431, -0.003402589587494731, -0.004227083642035723, -0.004514639265835285, -0.004193576984107494, -0.003354534739628434, -0.002224493306130171, -0.0011047790758311749, -0.00028996169567108154, 1.0531354746490251e-05, -0.000272760255029425, -0.001052407780662179, -0.002109155524522066, -0.0031518202740699053, -0.0038956841453909874, -0.00413829181343317, -0.003812487004324794, -0.0030028163455426693, -0.0019213370978832245, -0.0008497191593050957, -6.344365829136223e-05, 0.00024151209800038487, 1.4001335504105377e-17, -0.000706396356690675, -0.0016727279871702194, -0.0026266600470989943, -0.0033017918467521667, -0.0035085941199213266, -0.0031840885058045387, -0.0024072665255516768, -0.0013765105977654457, -0.00035545090213418007, 0.0003979755856562406, 0.0007001801277510822, 0.0004900205531157553, -0.00015624804655089974, -0.0010467974934726954, -0.0019266105955466628, -0.0025461395271122456, -0.002727766986936331, -0.0024123829789459705, -0.0016738827107474208, -0.0006980641046538949, 0.0002680696197785437, 0.0009827743051573634, 0.001273917150683701, 0.0010840900940820575, 0.0004846685042139143, -0.0003446005575824529, -0.0011646740604192019, -0.001741568325087428, -0.0019086813554167747, -0.0016104958485811949, -0.0009162125643342733, -1.068486402591487e-17, 0.0009065218619070947, 0.0015766075812280178, 0.001848754589445889, 0.0016690443735569715, 0.0011043661506846547, 0.000323299813317135, -0.00044989850721322, -0.0009956688154488802, -0.0011576301185414195, -0.0008836104534566402, -0.00023846914700698107, 0.0006144075887277722, 0.001457679201848805, 0.0020785368978977203, 0.0023253709077835083, 0.0021475309040397406, 0.0016077631153166294, 0.0008642916800454259, 0.00012763807899318635, -0.00039604678750038147, -0.0005598951829597354, -0.0003148592950310558, 0.00027822807896882296, 0.0010660074185580015, 0.0018444304587319493, 0.0024136740248650312, 0.00263135670684278, 0.002449893392622471, 0.001928190584294498, 0.0012148357927799225, 0.000507556542288512, 1.7176656882569836e-17, -0.0001698456471785903, 4.414071372593753e-05, 0.0005848700529895723, 0.0013083305675536394, 0.0020228771027177572, 0.002540813758969307, 0.0027283879462629557, 0.0025408908259123564, 0.0020336564630270004, 0.0013462791685014963, 0.000664534280076623, 0.00017037958605214953, -6.507590114779305e-06, 0.0001772442483343184, 0.0006680339574813843, 0.001330582657828927, 0.001984844682738185, 0.002454472007229924, 0.002613794757053256, 0.0024208046961575747, 0.0019275008235126734, 0.001265062252059579, 0.0006080704624764621, 0.0001275282265851274, -5.4684027418261394e-05, 0.00010221502452623099, 0.0005478792008943856, 0.0011552039068192244, 0.001755010918714106, 0.0021815914660692215, 0.00231685652397573, 0.002121338155120611, 0.0016439090250059962, 0.001007856335490942, 0.0003772552008740604, -8.718114258954301e-05, -0.0002709019463509321, -0.000135571594000794, 0.00027150599635206163, 0.0008308910182677209, 0.0013836038997396827, 0.0017739261966198683, 0.0018908914644271135, 0.0016974189784377813, 0.001239447738043964, 0.0006328450399450958, 3.1806535844225436e-05, -0.0004126357671339065, -0.0005928344908170402, -0.00047276716213673353, -9.688969294074923e-05, 0.0004225563898216933, 0.0009361775009892881, 0.0012976499274373055, 0.0014027084689587355, 0.0012165190419182181, 0.0007822586339898407, 0.00020880911324638873, -0.00035893928725272417, -0.0007790775271132588, -0.0009504693443886936, -0.00083928246749565, -0.00048730228445492685, -7.62292594837428e-18, 0.00048225425416603684, 0.0008219839073717594, 0.0009212356526404619, 0.000747292535379529, 0.000340728263836354, -0.00019616138888522983, -0.0007272624643519521, -0.0011192731326445937, -0.0012772053014487028, -0.0011693013366311789, -0.0008348380797542632, -0.0003729095042217523, 8.461952529614791e-05, 0.0004086146072950214, 0.0005070759216323495, 0.00034928403329104185, -2.664402563823387e-05, -0.0005246283835731447, -0.0010168402222916484, -0.0013781064189970493, -0.001519247773103416, -0.0014104736037552357, -0.0010886986274272203, -0.0006470017251558602, -0.00020922093244735152, 0.00010338503489037976, 0.00020443875109776855, 6.510801904369146e-05, -0.0002788091078400612, -0.0007371039246208966, -0.0011897752992808819, -0.0015193319413810968, -0.0016420872416347265, -0.0015301121165975928, -0.001218094490468502, -0.0007934316527098417, -0.0003723778063431382, -6.874802056699991e-05, 3.6395755159901455e-05, -8.399232319789007e-05, -0.0003963040071539581, -0.000815879087895155, -0.0012301160022616386, -0.0015287866117432714, -0.0016333985840901732, -0.0015177855966612697, -0.0012145303189754486, -0.0008056588703766465, -0.00040025170892477036, -0.00010508236300665885, 3.81767267754185e-06, -9.890418004943058e-05, -0.00038170741754584014, -0.0007651773630641401, -0.0011437099892646074, -0.0014139473205432296, -0.0015023102751001716, -0.0013842994812875986, -0.0010905055096372962, -0.0006978694000281394, -0.0003086823271587491, -2.3050728486850858e-05, 8.775861351750791e-05, 6.401356373103931e-18, -0.0002567386254668236, -0.0006080028833821416, -0.0009548084926791489, -0.0012002969160676003, -0.001275537651963532, -0.0011576066026464105, -0.0008752061403356493, -0.0005004614940844476, -0.00012923209578730166, 0.00014469104644376785, 0.00025455644936300814, 0.00017814457532949746, -5.6800421589287e-05, -0.00038051625597290695, -0.0007002820493653417, -0.0009253896423615515, -0.0009913065005093813, -0.0008765975944697857, -0.0006081733736209571, -0.0002535951789468527, 9.737145592225716e-05, 0.000356920383637771, 0.00046258053043857217, 0.0003935820423066616, 0.0001759274600772187, -0.00012506016355473548, -0.0004225876182317734, -0.0006317677907645702, -0.0006922297761775553, -0.0005839445511810482, -0.00033212287235073745, -2.5175802771506708e-17, 0.00032843390363268554, 0.0005710445111617446, 0.0006694185431115329, 0.0006041626911610365, 0.00039963365998119116, 0.00011695343710016459, -0.00016269573825411499, -0.00035993667552247643, -0.00041833691648207605, -0.0003191963769495487, -8.611240627942607e-05, 0.00022177983191795647, 0.0005259629106149077, 0.000749677128624171, 0.0008383546373806894, 0.000773908628616482, 0.0005791390431113541, 0.0003111912519671023, 4.593559424392879e-05, -0.0001424666988896206, -0.00020131090423092246, -0.00011315311712678522, 9.993930143537e-05, 0.000382716185413301, 0.0006618445622734725, 0.0008656559512019157, 0.0009432252263650298, 0.0008777034236118197, 0.0006904168985784054, 0.000434746325481683, 0.00018153298879042268, 7.115355516802553e-18, -6.067633876227774e-05, 1.5759604139020666e-05, 0.00020869035506621003, 0.000466545025119558, 0.00072089972672984, 0.0009049061336554587, 0.0009710874292068183, 0.0009037656709551811, 0.0007228716858662665, 0.0004782211617566645, 0.0002358942001592368, 6.0439357184804976e-05, -2.306859187228838e-06, 6.278674118220806e-05, 0.00023647515627089888, 0.0004706697363872081, 0.0007015920709818602, 0.0008669544477015734, 0.0009225416579283774, 0.0008537820540368557, 0.0006792831118218601, 0.00044548549340106547, 0.0002139623829862103, 4.483817974687554e-05, -1.9211298422305845e-05, 3.5880795621778816e-05, 0.0001921673392644152, 0.0004048529954161495, 0.0006145522929728031, 0.0007632895722053945, 0.0008099317783489823, 0.0007409501704387367, 0.0005736980237998068, 0.00035142048727720976, 0.00013142655370756984, -3.0344954211614095e-05, -9.420819696970284e-05, -4.710363646154292e-05, 9.424774907529354e-05, 0.00028816290432587266, 0.0004794074920937419, 0.0006140790064819157, 0.0006539546884596348, 0.0005864880513399839, 0.0004278426058590412, 0.00021824064606335014, 1.0958061466226354e-05, -0.00014202346210367978, -0.00020384464005474, -0.00016239866090472788, -3.324902354506776e-05, 0.00014486012514680624, 0.00032061367528513074, 0.0004439539334271103, 0.00047940341755747795, 0.0004153390182182193, 0.0002667971421033144, 7.11416796548292e-05, -0.00012216207687743008, -0.00026487058494240046, -0.00032279419247061014, -0.00028472606209106743, -0.00016513759328518063, -3.8706667721693975e-18, 0.00016306892212014645, 0.0002776372421067208, 0.0003108146775048226, 0.0002518457768019289, 0.00011469975288491696, -6.595918239327148e-05, -0.0002442627737764269, -0.00037549459375441074, -0.0004279832646716386, -0.00039137061685323715, -0.0002790980215650052, -0.00012452249939087778, 2.8222922992426902e-05, 0.00013612238399218768, 0.00016872136620804667, 0.00011607917986111715, -8.844051990308799e-06, -0.00017393067537341267, -0.0003367032913956791, -0.0004557691572699696, -0.0005018288502469659, -0.0004653225187212229, -0.00035872054286301136, -0.00021291719167493284, -6.876453699078411e-05, 3.393661609152332e-05, 6.702285463688895e-05, 2.1317706341505982e-05, -9.11709648789838e-05, -0.0002407240535831079, -0.0003880558942910284, -0.0004949007416144013, -0.0005341893411241472, -0.0004971110611222684, -0.000395220733480528, -0.0002570955257397145, -0.00012050154327880591, -2.2217256628209725e-05, 1.1746270502044354e-05, -2.7071080694440752e-05, -0.0001275583344977349, -0.0002622516476549208, -0.0003948647063225508, -0.0004900683998130262, -0.0005228864029049873, -0.00048520881682634354, -0.0003877284179907292, -0.0002568438649177551, -0.00012742301623802632, -3.340712282806635e-05, 1.2119937764509814e-06, -3.135499719064683e-05, -0.00012084013724233955, -0.0002418962394585833, -0.0003610500134527683, -0.0004457252216525376, -0.00047290537622757256, -0.0004351343959569931, -0.00034229306038469076, -0.00021873562945984304, -9.661185322329402e-05, -7.204018857009942e-06, 2.7387335649109446e-05, 5.498497006308427e-18, -7.988878496689722e-05, -0.00018891443323809654, -0.0002962368307635188, -0.00037185463588684797, -0.00039458266110159457, -0.00035757277510128915, -0.0002699423930607736, -0.00015413005894515663, -3.974126229877584e-05, 4.4428954424802214e-05, 7.804777123965323e-05, 5.4538057156605646e-05, -1.736313606670592e-05, -0.00011614436516538262, -0.00021342492254916579, -0.0002816066553350538, -0.00030121137388050556, -0.0002659548190422356, -0.0001842375349951908, -7.670683407923207e-05, 2.9408049158519134e-05, 0.00010763327736640349, 0.0001392844133079052, 0.00011832858581328765, 5.281127232592553e-05, -3.748434755834751e-05, -0.00012646932736970484, -0.00018878302944358438, -0.0002065343433059752, -0.0001739601866574958, -9.878996934276074e-05, -2.683390657529426e-18, 9.739420056575909e-05, 0.00016907929966691881, 0.00019790345686487854, 0.0001783383486326784, 0.00011778450425481424, 3.441711305640638e-05, -4.7804984205868095e-05, -0.00010559877409832552, -0.00012254485045559704, -9.336052607977763e-05, -2.5148261556751095e-05, 6.466983904829249e-05, 0.00015313444600906223, 0.00021793691848870367, 0.00024334577028639615, 0.00022429833188652992, 0.0001675947569310665, 8.99180886335671e-05, 1.3252943972474895e-05, -4.104126855963841e-05, -5.790556679130532e-05, -3.2498737709829584e-05, 2.866055910999421e-05, 0.00010959102655760944, 0.00018923680181615055, 0.00024714283063076437, 0.0002688889508135617, 0.00024984002811834216, 0.00019623854313977063, 0.00012338704254943877, 5.1446055294945836e-05, 2.2895790668796676e-18, -1.714543395792134e-05, 4.4467665247793775e-06, 5.879953459952958e-05, 0.0001312623789999634, 0.00020253470574971288, 0.00025386858033016324, 0.00027204930665902793, 0.00025283204740844667, 0.00020194248645566404, 0.00013341013982426375, 6.571647827513516e-05, 1.681425237620715e-05, -6.408894819287525e-07, 1.7419602954760194e-05, 6.551911064889282e-05, 0.00013023120118305087, 0.0001938670320669189, 0.00023924370179884136, 0.0002542492584325373, 0.00023499289818573743, 0.00018672282749321312, 0.00012229930143803358, 5.866468927706592e-05, 1.2278390386200044e-05, -5.254237748886226e-06, 9.801218766369857e-06, 5.242860788712278e-05, 0.00011032214388251305, 0.000167265665368177, 0.0002075037482427433, 0.00021992780966684222, 0.00020096584921702743, 0.00015542640176136047, 9.510067320661619e-05, 3.552726047928445e-05, -8.193968824343756e-06, -2.541166395531036e-05, -1.2692377822531853e-05, 2.5369468858116306e-05, 7.748867210466415e-05, 0.00012878721463494003, 0.00016480422345921397, 0.00017533815116621554, 0.0001571017928654328, 0.00011450071906438097, 5.835404954268597e-05, 2.9274508506205166e-06, -3.790931077674031e-05, -5.43656678928528e-05, -4.327703209128231e-05, -8.853469807945658e-06, 3.854370515909977e-05, 8.524466102244332e-05, 0.00011795444879680872, 0.00012728574802167714, 0.0001102033638744615, 7.074540917528793e-05, 1.8852881112252362e-05, -3.235478652641177e-05, -7.011265552137047e-05, -8.540068665752187e-05, -7.529193680966273e-05, -4.364813139545731e-05, -1.3635019810607187e-18, 4.306529081077315e-05, 7.329467189265415e-05, 8.202542085200548e-05, 6.644282984780148e-05, 3.025218211405445e-05, -1.7392614608979784e-05, -6.439574644900858e-05, -9.897581185214221e-05, -0.00011279583122814074, -0.00010313616076018661, -7.354480476351455e-05, -3.281193130533211e-05, 7.436885880451882e-06, 3.587075480027124e-05, 4.446518141776323e-05, 3.0595714633818716e-05, -2.3314789814321557e-06, -4.5861484977649525e-05, -8.880333916749805e-05, -0.00012024173338431865, -0.00013243811554275453, -0.00012285070260986686, -9.474693797528744e-05, -5.626324127661064e-05, -1.8180402548750862e-05, 8.977442121249624e-06, 1.7740776456776075e-05, 5.646464160236064e-06, -2.416573988739401e-05, -6.3854553445708e-05, -0.00010301895235897973, -0.00013149625738151371, -0.00014206438208930194, -0.00013233069330453873, -0.00010531422594795004, -6.858119741082191e-05, -3.218027632101439e-05, -5.940158189332578e-06, 3.144430593238212e-06, -7.256151548062917e-06, -3.4236789360875264e-05, -7.048727275105193e-05, -0.00010628556628944352, -0.00013211181794758886, -0.0001411812991136685, -0.00013122284144628793, -0.00010503781231818721, -6.970295362407342e-05, -3.464342080405913e-05, -9.099763701669872e-06, 3.3077833450079197e-07, -8.574659659643658e-06, -3.3114854886662215e-05, -6.643097003689036e-05, -9.937275171978399e-05, -0.00012295735359657556, -0.00013076094910502434, -0.00012060716835549101, -9.510938980383798e-05, -6.093269257689826e-05, -2.698341995710507e-05, -2.0174720702925697e-06, 7.690937309234869e-06, 1.6709011150443594e-18, -2.2563262973562814e-05, -5.351450454327278e-05, -8.417192293563858e-05, -0.0001059876085491851, -0.00011282508057774976, -0.00010257703979732469, -7.769754301989451e-05, -4.4515029003378004e-05, -1.1517996426846366e-05, 1.2922615496790968e-05, 2.278385181853082e-05, 1.5980192983988672e-05, -5.106929165776819e-06, -3.429358548601158e-05, -6.326693983282894e-05, -8.381575753446668e-05, -9.002008300740272e-05, -7.981700036907569e-05, -5.552899165195413e-05, -2.3220116418087855e-05, 8.941697160480544e-06, 3.287445360911079e-05, 4.273735248716548e-05, 3.6477325920714065e-05, 1.6357738786609843e-05, -1.1666620594041888e-05, -3.95561582990922e-05, -5.934182263445109e-05, -6.525212666019797e-05, -5.524489461095072e-05, -3.1537732866127044e-05, -4.676419270954239e-18, 3.142736022709869e-05, 5.485889414558187e-05, 6.456949631683528e-05, 5.85156049055513e-05, 3.8869009586051106e-05, 1.1423881915106904e-05, -1.5961430108291097e-05, -3.54692674591206e-05]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[0.00010115444456459954, 8.08848470381505e-18, -1.6640809281757984e-17, -1.0992760502241808e-17, -0.00010168126755161211, -0.0, -0.00010199211101280525, 5.9524012005086315e-18, 2.5492676639021684e-18, 1.9549601072738976e-18, 0.00010270974598824978, -0.0, 0.0001031169667840004, 3.1925281827716338e-18, -1.195509911816355e-17, 7.278098339238686e-18, -0.00010402931366115808, -0.0, -0.000104534876300022, 1.1245188728232777e-17, -5.9439875329080484e-18, 1.0170259250413992e-17, 0.00010564584954408929, -0.0, 0.00010625171853462234, -1.933125847824948e-18, -3.630475856160537e-18, -7.8351405820908305e-19, -0.00010756527626654133, -0.0, -0.00010827343066921458, -4.6343542416737736e-18, 1.357228932808331e-17, -8.954878640486766e-18, 0.00010979356738971546, -0.0, 0.00011060598626499996, -1.060371843500403e-17, 5.295900208369183e-18, -6.30065044224805e-18, -0.0001123366819228977, -0.0, -0.0001132553952629678, 7.216937328529551e-19, 8.661205534792677e-18, -3.77166772850752e-18, 0.00011520068073878065, -0.0, 0.00011622769670793787, 9.669126765549767e-18, -1.951371177391183e-17, 1.1027665042549708e-17, -0.00011839163926197216, -0.0, -0.0001195290096802637, 6.651942054280439e-18, -6.813677474128059e-19, 5.403969701038011e-18, 0.00012191568384878337, -0.0, 0.0001231654459843412, 6.705680773353136e-19, -1.0564690399342553e-17, 5.581555865976102e-18, -0.0001257789699593559, -0.0, -0.00012714321201201528, -1.2094891814504399e-17, -1.1199669806304597e-17, 1.2092739490550536e-17, 0.0001299877476412803, -0.0, 0.00013146853598300368, -5.763253118558581e-18, -4.817739356296167e-18, -5.830370139870827e-19, -0.00013454828877002, -0.0, -0.00013614770432468504, -6.2419553603425126e-18, 1.7465979845422508e-17, -1.175551201688308e-17, 0.00013946689432486892, -0.0, 0.00014118710532784462, -1.3158210158064777e-17, 6.468980869721979e-18, -1.176499233388355e-17, -0.00014474995259661227, -0.0, -0.00014659309817943722, 5.011945751089556e-19, 6.723039468700291e-18, -1.1015430834494895e-18, 0.00015040395373944193, -0.0, 0.0001523721730336547, -8.641413584276121e-18, -7.008066469041669e-19, -2.6596350643126687e-18, -0.00015643535880371928, -0.0, -0.00015853084914851934, -5.242782391743784e-18, -5.816382102122249e-18, 6.734190690538118e-18, 0.00016285080346278846, -0.0, 0.00016507574764546007, 1.3849559442230472e-18, -1.458430593005315e-17, 8.013843234060715e-18, -0.0001696568651823327, -0.0, -0.00017201353330165148, 2.797817240000877e-18, 8.094769622109228e-18, 9.456538659786648e-19, 0.0001768603251548484, -0.0, 0.00017935095820575953, -7.345658315768955e-18, -1.031424533887018e-18, -5.471341493978924e-18, -0.000184467964572832, -0.0, -0.00018709486175794154, -3.7864031239395394e-18, 1.8256518011200662e-17, 1.0388546423802449e-17, 0.00019248668104410172, -0.0, 0.00019525217066984624, -8.634543952686445e-19, -1.0985476349767666e-17, 6.943305258113974e-18, -0.00020092347403988242, -0.0, -0.000203829855308868, 5.9283678814012096e-18, 9.830986986272305e-18, -2.1494139324680165e-18, 0.00020978538668714464, -0.0, 0.00021283506066538393, -1.1439684532842983e-17, -1.4687714673560547e-18, -3.0880407957454667e-18, -0.00021907959308009595, -0.0, -0.0002222749899374321, -8.015112129120371e-18, 2.1951131797697336e-17, 1.5245042914109482e-17, 0.00022881338372826576, -0.0, 0.00023215696273837239, 2.6381219577365427e-18, -1.3331086770185297e-17, 5.2317085112932304e-18, -0.00023899416555650532, -0.0, -0.00024248835688922554, 1.0176665764258216e-17, 3.9008774760913655e-18, 6.03640325286977e-19, 0.0002496293745934963, -0.0, 0.00025327675393782556, 1.2133824724395432e-17, -2.0386548620374723e-18, -6.976778775962157e-18, -0.0002607267233543098, -0.0, -0.0002645298663992435, -6.139966885946868e-18, 2.6427148367287128e-17, -1.682550382329005e-17, 0.0002722939243540168, -0.0, 0.000276255450444296, -4.013072428667725e-19, -1.6179093607443135e-17, 2.6418620548762012e-18, -0.00028433892293833196, -0.0, -0.00028846150962635875, 7.551809922390645e-18, 4.9708591730761645e-18, 4.4776237815199824e-18, 0.0002968697517644614, -0.0, 0.0003011560474988073, 1.0557239156384675e-17, 7.256797611284833e-18, -1.2208222175869064e-17, -0.00030989458900876343, -0.0, -0.00031434744596481323, -3.2672275551688475e-18, 2.1293180757944082e-17, -1.589097501956234e-17, 0.0003234218747820705, -0.0, 0.0003280440578237176, -4.69064470953862e-18, -1.9583438136466376e-17, 8.37661487222442e-18, -0.00033746007829904556, -0.0, -0.00034225452691316605, 1.3333211797178946e-17, 6.2887597209426005e-18, 9.769039430198209e-18, 0.00035201801802031696, -0.0, 0.0003569876425899565, 1.8146488100480083e-17, 8.189805229866057e-18, -1.911452764518354e-17, -0.00036710454151034355, -0.0, -0.0003722524270415306, -9.743089120021196e-18, 2.563376139147934e-17, -1.3960060845900206e-17, 0.00038272884557954967, -0.0, 0.00038805807707831264, -1.0519448582919578e-17, -1.069028454046893e-17, 4.8502136399643866e-18, -0.0003989003016613424, -0.0, -0.0004044140223413706, 2.0945766555033035e-17, 7.891863872211195e-18, 5.0671003965757904e-18, 0.00041562848491594195, -0.0, 0.00042132995440624654, 1.600189001353835e-17, -4.6887654379049605e-17, -1.5807112140339264e-17, -0.0004329232615418732, -0.0, -0.0004388158267829567, -5.8476565603119604e-18, 3.0708183577247145e-17, -1.0763198029923641e-17, 0.0004507947014644742, -0.0, 0.0004568817967083305, -5.1593885239280255e-18, -1.3104811513621416e-17, -2.3902973537459485e-19, -0.00046925328206270933, -0.0, -0.00047553839976899326, 3.0730487675284025e-17, -5.993928148800631e-18, 1.2126567868881505e-17, 0.0004883095389232039, -0.0, 0.0004947964334860444, 1.2450892979354358e-17, -3.915328073238483e-17, -2.4988613453247183e-17, -0.0005079747061245143, -0.0, -0.0005146669573150575, -2.4904244649681954e-19, 3.6590559389409794e-17, -2.0857605645347134e-17, 0.0005282597849145532, -0.0, 0.0005351613508537412, -1.2912749274373341e-17, -1.595677889165216e-17, -7.204901126833869e-18, -0.0005491767660714686, -0.0, -0.0005562916048802435, 2.716672393552589e-17, -6.371297870414673e-18, 2.1410347582989768e-17, 0.0005707375821657479, -0.0, 0.0005780698265880346, 2.3660700711246405e-17, -4.638532744538085e-17, -3.667210285419527e-17, -0.0005929546896368265, -0.0, -0.0006005084724165499, 7.398525910259056e-18, 2.3405005949016464e-17, -1.6514621224951795e-17, 0.0006158410687930882, -0.0, 0.0006236208137124777, -2.3048631725710243e-17, -1.9300825262742734e-17, 1.5884899377963138e-18, -0.0006394098745658994, -0.0, -0.0006474201218225062, -3.417845109236841e-17, -6.670324902623511e-18, 1.4522621417413845e-17, 0.0006636749021708965, -0.0, 0.0006719205412082374, 1.889425275678312e-17, -5.466321831149707e-17, 2.6498462916617774e-17, -0.0006886506453156471, -0.0, -0.000697136449161917, -2.4053324470536538e-18, 2.795832420121056e-17, -1.0057981062788495e-17, 0.0007143518887460232, -0.0, 0.0007230828050523996, -3.60220778590715e-17, 8.21702919139125e-19, -7.551704043272239e-18, -0.0007407939410768449, -0.0, -0.000749775383155793, -2.9952547470235054e-17, -3.17674479086254e-17, 2.6546373217696846e-17, 0.0007679929258301854, -0.0, 0.000777230248786509, 1.187787684489805e-17, -6.409579044701076e-17, 4.3059641175166504e-17, -0.000795965373981744, -0.0, -0.0008054644567891955, 7.530695310074617e-18, 3.321252251258819e-17, -1.2087244943331653e-18, 0.0008247288060374558, -0.0, 0.0008344954694621265, -2.8355397365015616e-17, -7.241884675751496e-21, -1.9516764070372152e-17, -0.0008543012081645429, -0.0, -0.0008643416222184896, -2.3461168203886364e-17, -3.5618936498292756e-17, 4.1777395420423554e-17, 0.0008847013232298195, -0.0, 0.0008950220653787255, 2.221559798314279e-18, -4.5092662523642184e-17, 3.794280447630943e-17, -0.0009159490000456572, -0.0, -0.0009265567641705275, 2.054830461634008e-17, 3.925274754668311e-17, -1.6193297952921896e-17, 0.0009480647277086973, -0.0, 0.0009589664987288415, -4.4881575957486e-17, -1.1056250129772856e-18, -7.159541850763911e-18, -0.000981069984845817, -0.0, -0.0009922732133418322, -4.253672075296763e-17, 9.200180705500592e-17, 6.081138710680771e-17, 0.001014987239614129, -0.0, 0.0010264997836202383, 4.0693836794454615e-18, -5.287477441781862e-17, 3.0246428198262893e-17, -0.0010498401243239641, -0.0, -0.0010616699000820518, 2.2001351587046655e-17, 2.8560356177194005e-17, -4.7749439265348176e-18, 0.0010856532026082277, -0.0, 0.001097808824852109, -6.545337912066749e-17, 1.569440051007279e-17, -2.2395218598797455e-17, -0.0011224525514990091, -0.0, -0.0011349428677931428, -3.4125154191140395e-17, 8.766766519535877e-17, 6.786107027323784e-17, 0.001160265295766294, -0.0, 0.001173099735751748, 6.3511030829398034e-18, -6.175128927579456e-17, 3.6233647498705413e-17, -0.0011991200735792518, -0.0, -0.0012123084161430597, 4.059010007383434e-17, 1.3879177471243546e-17, -7.18808619934189e-18, 0.0012390469200909138, -0.0, 0.0012525994097813964, -7.285647354944968e-17, 3.724895214361015e-17, -4.1783314724886983e-17, -0.001280077500268817, -0.0, -0.0012940051965415478, -4.082114816253265e-17, 1.0141002037584114e-16, -7.40984951653654e-17, 0.001322244992479682, -0.0, 0.0013365597696974874, -9.862313970430914e-18, -4.9698940187374376e-17, 2.39425922834759e-17, -0.0013655850198119879, -0.0, -0.0013802986359223723, 4.416379494402679e-17, 1.7377291194505798e-17, 9.619989755622279e-18, 0.0014101344859227538, -0.0, 0.0014252598630264401, 6.176610573492661e-17, 4.0745067398512475e-17, -4.534673932059397e-17, -0.0014559327391907573, -0.0, -0.0014714833814650774, -2.7593238111692932e-17, 9.257541379641959e-17, -6.526218790260443e-17, 0.0015030212234705687, -0.0, 0.0015190115664154291, -8.956279884444431e-18, -5.820974526165082e-17, 2.9478834368315736e-17, -0.0015514439437538385, -0.0, -0.0015678893541917205, 7.026674310511356e-17, -4.472195408750103e-18, 8.576369891169239e-18, 0.0016012475825846195, -0.0, 0.0016181640094146132, 7.257075213098406e-17, 7.123579511888678e-17, -7.254596979983197e-17, -0.0016524813836440444, -0.0, -0.0016698860563337803, -3.373242207119002e-17, 1.0695153490990539e-16, -7.654671155050594e-17, 0.0017051977338269353, -0.0, 0.0017231086967512965, -3.219792262556535e-17, -3.942043360045986e-17, 1.1219209466734325e-17, -0.0017594522796571255, -0.0, -0.0017778894398361444, -2.451491854930134e-17, -3.251762793231709e-17, 3.275861211453339e-17, 0.0018153047421947122, -0.0, 0.0018342878902330995, -1.9855661621696352e-17, -4.3010496720613503e-17, 2.651197243038199e-17, -0.0018728177528828382, -0.0, -0.001892369007691741, -1.4021927338274272e-17, 9.197711075063753e-17, 4.700147774005935e-17, 0.0019320584833621979, -0.0, 0.0019522017100825906, -3.364725555532156e-17, -4.688978188758509e-17, 1.563266636659673e-17, -0.001993098994717002, -0.0, -0.002013858873397112, -2.0112218306124574e-18, 9.903094967246513e-17, 3.4022352184612305e-17, 0.0020560158882290125, -0.0, 0.002077419077977538, -4.912339784332733e-17, -1.6640243490218998e-17, 3.1106219992875518e-18, -0.002120890887454152, -0.0, -0.002142966026440263, -1.8985239315441503e-17, 1.0660403302584941e-16, 5.015446193326243e-17, 0.0021878115367144346, -0.0, 0.002210589125752449, -6.644443413873462e-17, -1.8970432782476804e-17, 2.0867692285736605e-17, -0.0022568723652511835, -0.0, -0.002280385233461857, -5.5833206558129835e-18, 7.693542026395686e-17, 6.806939405614809e-17, 0.00232817349024117, -0.0, 0.0023524570278823376, -5.221731141462677e-17, -2.1532864612237447e-17, 7.04519240288458e-18, -0.0024018241092562675, -0.0, -0.0024269158020615578, 9.538762273830797e-18, 8.326875840247117e-17, 8.816868518365969e-17, 0.0024779399391263723, -0.0, 0.002503880998119712, 7.155166561631873e-17, -2.4350987895505582e-17, -8.80335817742114e-18, -0.0025566467083990574, -0.0, -0.0025834813714027405, 2.6717688940001478e-17, 9.01218703681342e-17, -7.586503531642344e-17, 0.0026380799245089293, -0.0, 0.002665855223312974, 5.909093745948111e-17, 1.6754199200126753e-17, -2.6558918238866825e-17, -0.002722386037930846, -0.0, -0.0027511534281075, 6.825114797060253e-18, 9.755066033546473e-17, -6.306177497665007e-17, 0.0028097229078412056, -0.0, 0.0028395378030836582, 4.473740499416291e-17, 1.6224055836819068e-17, -5.54763567059714e-18, -0.0029002614319324493, -0.0, -0.0029311843682080507, 2.606620314391594e-17, 5.700780550949697e-17, -4.8107984010581736e-17, 0.002994188340380788, -0.0, 0.0030262847431004047, 7.157215322573044e-17, 1.5562812618227853e-17, -2.572365441736793e-17, -0.0030917052645236254, -0.0, -0.0031250459142029285, 4.783023661322113e-17, 6.257254065771681e-17, -3.114610291970007e-17, 0.003193032229319215, -0.0, 0.0032276951242238283, 5.574752636310098e-17, 6.829580331597121e-17, -4.8153985178807035e-17, -0.0032984083518385887, -0.0, -0.003334478475153446, 2.4499016829205622e-17, 6.868313560088284e-17, -5.974731520170929e-17, 0.0034080964978784323, -0.0, 0.0034456662833690643, 3.742040021481279e-17, 7.094988179451905e-17, -7.387304543505284e-17, -0.0035223832819610834, -0.0, -0.003561554243788123, 4.901105348125283e-17, 7.541131020682586e-17, -4.0853957454348955e-17, 0.003641583491116762, -0.0, 0.0036824673879891634, 1.637826711841733e-17, -1.706941457051356e-16, -4.9449187890665016e-17, -0.003766042646020651, -0.0, -0.003808762179687619, 7.684820234016927e-17, 5.123755568372711e-17, -4.668448889443923e-17, 0.0038961414247751236, -0.0, 0.0039408328011631966, 2.0324105583113708e-17, -1.5226483959013997e-16, -7.863669917340693e-17, -0.004032301716506481, -0.0, -0.004079114180058241, 7.942123697102162e-17, 2.3365698326307944e-17, -2.3412996513733726e-17, 0.004174988251179457, -0.0, 0.004224088508635759, 2.505635127360915e-17, -1.6567486668772304e-16, -1.114707402336378e-16, -0.004324717912822962, -0.0, -0.0043762908317148685, 1.1329867703848198e-16, 2.7581080211049627e-17, -2.8557831621964493e-17, 0.004482066724449396, -0.0, 0.004536318127065897, -2.194002276207075e-18, -1.4290854012454857e-16, -1.1651629050730505e-16, -0.00464767636731267, -0.0, -0.004704836755990982, 1.1833796720927344e-16, -6.7217751231340034e-18, -0.0, 0.004822264891117811, -0.0, 0.004882592707872391, 1.259713561652159e-18, -1.5667733861485304e-16, -1.5737898629764502e-16, -0.005006639752537012, -0.0, -0.005070426966995001, 1.504575690657198e-17, -4.6476952587472126e-17, -3.644178103007478e-18, 0.0052017103880643845, -0.0, 0.005269284825772047, 5.099286407800535e-18, -1.2838985277812803e-16, -1.3087731888333422e-17, -0.005408504977822304, -0.0, -0.005480239633470774, 1.2022770764076513e-17, 1.351374892895232e-16, 3.15350035390531e-17, 0.005628191865980625, -0.0, 0.0057045104913413525, -3.092350861686205e-17, -1.4234559408686948e-16, -1.0076055786353391e-17, -0.0058621009811758995, -0.0, -0.005943489260971546, 5.121352774129367e-17, 1.006152917130798e-16, 2.9759596011828484e-17, 0.006111757829785347, -0.0, 0.0061987717635929585, -2.901235413367258e-17, -1.0675286597910486e-16, -5.0945878564851113e-17, -0.006378914695233107, -0.0, -0.0064721968956291676, 5.1193139393555464e-17, 1.133629588982447e-16, 7.442969828263163e-17, 0.006665598135441542, -0.0, 0.006765895523130894, -7.515715400053526e-17, -1.2050078643074849e-16, -5.0796129095476963e-17, -0.006974165327847004, -0.0, -0.007082347758114338, 1.0156606634403805e-16, 6.921179003908793e-17, 7.644572934132547e-17, 0.007307372055947781, -0.0, 0.007424460258334875, -7.699639340126937e-17, -7.472662965275856e-17, -1.0457886327574809e-16, -0.0076684593223035336, -0.0, -0.007795661222189665, 1.0606184591282296e-16, 8.074958315566338e-17, 1.3500892556999775e-16, 0.008061269298195839, -0.0, 0.008200022391974926, 9.728414935954505e-17, -8.735165573158391e-17, 1.3001063708780933e-16, -0.008490387350320816, -0.0, -0.008642418310046196, -1.0592232370454241e-16, 5.852039459505634e-17, -1.0871259581658589e-16, 0.008961333893239498, -0.0, 0.009128729812800884, 8.239429614610461e-17, -2.63339184948075e-17, 8.487094107453738e-17, -0.009480811655521393, -0.0, -0.009666124358773232, -9.103700344085877e-17, 3.069686443774497e-17, -9.381678028529017e-17, 0.010057041421532631, -0.0, 0.01026342436671257, 1.003657941879991e-16, 7.393253461034643e-18, 6.583091758712649e-17, -0.010700220242142677, -0.0, -0.01093161292374134, 8.570937796086603e-17, -5.0556412153959096e-17, -7.458131056274525e-17, 0.011423147283494473, -0.0, 0.011684538796544075, 8.106442133169086e-17, -1.4548387762622627e-16, 4.18756479335826e-17, -0.012242116034030914, -0.0, -0.012539917603135109, -4.6379037564003e-17, 1.0727850947988025e-16, -5.004689205768358e-17, 0.013178186491131783, -0.0, 0.013520783744752407, 5.575647314860635e-17, -1.1979397714093418e-16, 5.861082859706554e-17, -0.014259074814617634, -0.0, -0.014657638035714626, -1.2863159796650787e-17, 7.253719506789401e-17, -1.5688209890368442e-17, 0.015522000379860401, -0.0, 0.015991751104593277, 1.9774659133031485e-17, -8.399168778806292e-17, 2.254652813080688e-17, -0.017018135637044907, -0.0, -0.017580373212695122, 3.4373264947924144e-18, 6.04524701302985e-17, 3.319307384202584e-17, 0.018819842487573624, -0.0, 0.01950528472661972, -3.1198781089829895e-17, -3.1514059325943257e-17, -6.743871185246826e-17, -0.021032866090536118, -0.0, -0.021887535229325294, 6.658891943069048e-17, -5.161553421027199e-17, -5.67649452816514e-17, 0.023818138986825943, -0.0, 0.02491418831050396, 6.865035939629104e-17, -1.0899306960124547e-16, 2.7442031150079463e-17, -0.02743314951658249, -0.0, -0.028890468180179596, -3.804638734133577e-17, 7.338631912773684e-17, 1.2071332883478276e-17, 0.0323171503841877, -0.0, 0.03435051813721657, -4.546560186589539e-18, -6.094262427407292e-17, -3.403301288834689e-17, -0.039285894483327866, -0.0, -0.04232153668999672, 6.63099081013539e-17, -5.1882809501077677e-17, -5.829090822335453e-17, 0.05004505068063736, -0.0, 0.05506337061524391, 3.52990459030838e-17, -7.359971849088572e-17, -8.307444375041511e-18, -0.06885881721973419, -0.0, -0.07870988547801971, 6.792170592086042e-17, -5.194978466091487e-17, -6.422609455454501e-17, 0.11022543907165527, -0.0, 0.13779661059379578, -3.533194453040626e-17, 5.1966533413957844e-17, 2.8267580562464536e-17, -0.27563270926475525, -0.0, -0.5512852072715759, -0.0, 1.333243489265442, 0.0, -0.5512852072715759, 0.0, -0.27563270926475525, 2.8267580562464536e-17, 5.1966533413957844e-17, -3.533194453040626e-17, 0.13779661059379578, 0.0, 0.11022543907165527, -6.422609455454501e-17, -5.194978466091487e-17, 6.792170592086042e-17, -0.07870988547801971, 0.0, -0.06885881721973419, -8.307444375041511e-18, -7.359971849088572e-17, 3.52990459030838e-17, 0.05506337061524391, 0.0, 0.05004505068063736, -5.829090822335453e-17, -5.1882809501077677e-17, 6.63099081013539e-17, -0.04232153668999672, 0.0, -0.039285894483327866, -3.403301288834689e-17, -6.094262427407292e-17, -4.546560186589539e-18, 0.03435051813721657, 0.0, 0.0323171503841877, 1.2071332883478276e-17, 7.338631912773684e-17, -3.804638734133577e-17, -0.028890468180179596, 0.0, -0.02743314951658249, 2.7442031150079463e-17, -1.0899306960124547e-16, 6.865035939629104e-17, 0.02491418831050396, 0.0, 0.023818138986825943, -5.67649452816514e-17, -5.161553421027199e-17, 6.658891943069048e-17, -0.021887535229325294, 0.0, -0.021032866090536118, -6.743871185246826e-17, -3.1514059325943257e-17, -3.1198781089829895e-17, 0.01950528472661972, 0.0, 0.018819842487573624, 3.319307384202584e-17, 6.04524701302985e-17, 3.4373264947924144e-18, -0.017580373212695122, 0.0, -0.017018135637044907, 2.254652813080688e-17, -8.399168778806292e-17, 1.9774659133031485e-17, 0.015991751104593277, 0.0, 0.015522000379860401, -1.5688209890368442e-17, 7.253719506789401e-17, -1.2863159796650787e-17, -0.014657638035714626, 0.0, -0.014259074814617634, 5.861082859706554e-17, -1.1979397714093418e-16, 5.575647314860635e-17, 0.013520783744752407, 0.0, 0.013178186491131783, -5.004689205768358e-17, 1.0727850947988025e-16, -4.6379037564003e-17, -0.012539917603135109, 0.0, -0.012242116034030914, 4.18756479335826e-17, -1.4548387762622627e-16, 8.106442133169086e-17, 0.011684538796544075, 0.0, 0.011423147283494473, -7.458131056274525e-17, -5.0556412153959096e-17, 8.570937796086603e-17, -0.01093161292374134, 0.0, -0.010700220242142677, 6.583091758712649e-17, 7.393253461034643e-18, 1.003657941879991e-16, 0.01026342436671257, 0.0, 0.010057041421532631, -9.381678028529017e-17, 3.069686443774497e-17, -9.103700344085877e-17, -0.009666124358773232, 0.0, -0.009480811655521393, 8.487094107453738e-17, -2.63339184948075e-17, 8.239429614610461e-17, 0.009128729812800884, 0.0, 0.008961333893239498, -1.0871259581658589e-16, 5.852039459505634e-17, -1.0592232370454241e-16, -0.008642418310046196, 0.0, -0.008490387350320816, 1.3001063708780933e-16, -8.735165573158391e-17, 9.728414935954505e-17, 0.008200022391974926, 0.0, 0.008061269298195839, 1.3500892556999775e-16, 8.074958315566338e-17, 1.0606184591282296e-16, -0.007795661222189665, 0.0, -0.0076684593223035336, -1.0457886327574809e-16, -7.472662965275856e-17, -7.699639340126937e-17, 0.007424460258334875, 0.0, 0.007307372055947781, 7.644572934132547e-17, 6.921179003908793e-17, 1.0156606634403805e-16, -0.007082347758114338, 0.0, -0.006974165327847004, -5.0796129095476963e-17, -1.2050078643074849e-16, -7.515715400053526e-17, 0.006765895523130894, 0.0, 0.006665598135441542, 7.442969828263163e-17, 1.133629588982447e-16, 5.1193139393555464e-17, -0.0064721968956291676, 0.0, -0.006378914695233107, -5.0945878564851113e-17, -1.0675286597910486e-16, -2.901235413367258e-17, 0.0061987717635929585, 0.0, 0.006111757829785347, 2.9759596011828484e-17, 1.006152917130798e-16, 5.121352774129367e-17, -0.005943489260971546, 0.0, -0.0058621009811758995, -1.0076055786353391e-17, -1.4234559408686948e-16, -3.092350861686205e-17, 0.0057045104913413525, 0.0, 0.005628191865980625, 3.15350035390531e-17, 1.351374892895232e-16, 1.2022770764076513e-17, -0.005480239633470774, 0.0, -0.005408504977822304, -1.3087731888333422e-17, -1.2838985277812803e-16, 5.099286407800535e-18, 0.005269284825772047, 0.0, 0.0052017103880643845, -3.644178103007478e-18, -4.6476952587472126e-17, 1.504575690657198e-17, -0.005070426966995001, 0.0, -0.005006639752537012, -1.5737898629764502e-16, -1.5667733861485304e-16, 1.259713561652159e-18, 0.004882592707872391, 0.0, 0.004822264891117811, 0.0, -6.7217751231340034e-18, 1.1833796720927344e-16, -0.004704836755990982, 0.0, -0.00464767636731267, -1.1651629050730505e-16, -1.4290854012454857e-16, -2.194002276207075e-18, 0.004536318127065897, 0.0, 0.004482066724449396, -2.8557831621964493e-17, 2.7581080211049627e-17, 1.1329867703848198e-16, -0.0043762908317148685, 0.0, -0.004324717912822962, -1.114707402336378e-16, -1.6567486668772304e-16, 2.505635127360915e-17, 0.004224088508635759, 0.0, 0.004174988251179457, -2.3412996513733726e-17, 2.3365698326307944e-17, 7.942123697102162e-17, -0.004079114180058241, 0.0, -0.004032301716506481, -7.863669917340693e-17, -1.5226483959013997e-16, 2.0324105583113708e-17, 0.0039408328011631966, 0.0, 0.0038961414247751236, -4.668448889443923e-17, 5.123755568372711e-17, 7.684820234016927e-17, -0.003808762179687619, 0.0, -0.003766042646020651, -4.9449187890665016e-17, -1.706941457051356e-16, 1.637826711841733e-17, 0.0036824673879891634, 0.0, 0.003641583491116762, -4.0853957454348955e-17, 7.541131020682586e-17, 4.901105348125283e-17, -0.003561554243788123, 0.0, -0.0035223832819610834, -7.387304543505284e-17, 7.094988179451905e-17, 3.742040021481279e-17, 0.0034456662833690643, 0.0, 0.0034080964978784323, -5.974731520170929e-17, 6.868313560088284e-17, 2.4499016829205622e-17, -0.003334478475153446, 0.0, -0.0032984083518385887, -4.8153985178807035e-17, 6.829580331597121e-17, 5.574752636310098e-17, 0.0032276951242238283, 0.0, 0.003193032229319215, -3.114610291970007e-17, 6.257254065771681e-17, 4.783023661322113e-17, -0.0031250459142029285, 0.0, -0.0030917052645236254, -2.572365441736793e-17, 1.5562812618227853e-17, 7.157215322573044e-17, 0.0030262847431004047, 0.0, 0.002994188340380788, -4.8107984010581736e-17, 5.700780550949697e-17, 2.606620314391594e-17, -0.0029311843682080507, 0.0, -0.0029002614319324493, -5.54763567059714e-18, 1.6224055836819068e-17, 4.473740499416291e-17, 0.0028395378030836582, 0.0, 0.0028097229078412056, -6.306177497665007e-17, 9.755066033546473e-17, 6.825114797060253e-18, -0.0027511534281075, 0.0, -0.002722386037930846, -2.6558918238866825e-17, 1.6754199200126753e-17, 5.909093745948111e-17, 0.002665855223312974, 0.0, 0.0026380799245089293, -7.586503531642344e-17, 9.01218703681342e-17, 2.6717688940001478e-17, -0.0025834813714027405, 0.0, -0.0025566467083990574, -8.80335817742114e-18, -2.4350987895505582e-17, 7.155166561631873e-17, 0.002503880998119712, 0.0, 0.0024779399391263723, 8.816868518365969e-17, 8.326875840247117e-17, 9.538762273830797e-18, -0.0024269158020615578, 0.0, -0.0024018241092562675, 7.04519240288458e-18, -2.1532864612237447e-17, -5.221731141462677e-17, 0.0023524570278823376, 0.0, 0.00232817349024117, 6.806939405614809e-17, 7.693542026395686e-17, -5.5833206558129835e-18, -0.002280385233461857, 0.0, -0.0022568723652511835, 2.0867692285736605e-17, -1.8970432782476804e-17, -6.644443413873462e-17, 0.002210589125752449, 0.0, 0.0021878115367144346, 5.015446193326243e-17, 1.0660403302584941e-16, -1.8985239315441503e-17, -0.002142966026440263, 0.0, -0.002120890887454152, 3.1106219992875518e-18, -1.6640243490218998e-17, -4.912339784332733e-17, 0.002077419077977538, 0.0, 0.0020560158882290125, 3.4022352184612305e-17, 9.903094967246513e-17, -2.0112218306124574e-18, -0.002013858873397112, 0.0, -0.001993098994717002, 1.563266636659673e-17, -4.688978188758509e-17, -3.364725555532156e-17, 0.0019522017100825906, 0.0, 0.0019320584833621979, 4.700147774005935e-17, 9.197711075063753e-17, -1.4021927338274272e-17, -0.001892369007691741, 0.0, -0.0018728177528828382, 2.651197243038199e-17, -4.3010496720613503e-17, -1.9855661621696352e-17, 0.0018342878902330995, 0.0, 0.0018153047421947122, 3.275861211453339e-17, -3.251762793231709e-17, -2.451491854930134e-17, -0.0017778894398361444, 0.0, -0.0017594522796571255, 1.1219209466734325e-17, -3.942043360045986e-17, -3.219792262556535e-17, 0.0017231086967512965, 0.0, 0.0017051977338269353, -7.654671155050594e-17, 1.0695153490990539e-16, -3.373242207119002e-17, -0.0016698860563337803, 0.0, -0.0016524813836440444, -7.254596979983197e-17, 7.123579511888678e-17, 7.257075213098406e-17, 0.0016181640094146132, 0.0, 0.0016012475825846195, 8.576369891169239e-18, -4.472195408750103e-18, 7.026674310511356e-17, -0.0015678893541917205, 0.0, -0.0015514439437538385, 2.9478834368315736e-17, -5.820974526165082e-17, -8.956279884444431e-18, 0.0015190115664154291, 0.0, 0.0015030212234705687, -6.526218790260443e-17, 9.257541379641959e-17, -2.7593238111692932e-17, -0.0014714833814650774, 0.0, -0.0014559327391907573, -4.534673932059397e-17, 4.0745067398512475e-17, 6.176610573492661e-17, 0.0014252598630264401, 0.0, 0.0014101344859227538, 9.619989755622279e-18, 1.7377291194505798e-17, 4.416379494402679e-17, -0.0013802986359223723, 0.0, -0.0013655850198119879, 2.39425922834759e-17, -4.9698940187374376e-17, -9.862313970430914e-18, 0.0013365597696974874, 0.0, 0.001322244992479682, -7.40984951653654e-17, 1.0141002037584114e-16, -4.082114816253265e-17, -0.0012940051965415478, 0.0, -0.001280077500268817, -4.1783314724886983e-17, 3.724895214361015e-17, -7.285647354944968e-17, 0.0012525994097813964, 0.0, 0.0012390469200909138, -7.18808619934189e-18, 1.3879177471243546e-17, 4.059010007383434e-17, -0.0012123084161430597, 0.0, -0.0011991200735792518, 3.6233647498705413e-17, -6.175128927579456e-17, 6.3511030829398034e-18, 0.001173099735751748, 0.0, 0.001160265295766294, 6.786107027323784e-17, 8.766766519535877e-17, -3.4125154191140395e-17, -0.0011349428677931428, 0.0, -0.0011224525514990091, -2.2395218598797455e-17, 1.569440051007279e-17, -6.545337912066749e-17, 0.001097808824852109, 0.0, 0.0010856532026082277, -4.7749439265348176e-18, 2.8560356177194005e-17, 2.2001351587046655e-17, -0.0010616699000820518, 0.0, -0.0010498401243239641, 3.0246428198262893e-17, -5.287477441781862e-17, 4.0693836794454615e-18, 0.0010264997836202383, 0.0, 0.001014987239614129, 6.081138710680771e-17, 9.200180705500592e-17, -4.253672075296763e-17, -0.0009922732133418322, 0.0, -0.000981069984845817, -7.159541850763911e-18, -1.1056250129772856e-18, -4.4881575957486e-17, 0.0009589664987288415, 0.0, 0.0009480647277086973, -1.6193297952921896e-17, 3.925274754668311e-17, 2.054830461634008e-17, -0.0009265567641705275, 0.0, -0.0009159490000456572, 3.794280447630943e-17, -4.5092662523642184e-17, 2.221559798314279e-18, 0.0008950220653787255, 0.0, 0.0008847013232298195, 4.1777395420423554e-17, -3.5618936498292756e-17, -2.3461168203886364e-17, -0.0008643416222184896, 0.0, -0.0008543012081645429, -1.9516764070372152e-17, -7.241884675751496e-21, -2.8355397365015616e-17, 0.0008344954694621265, 0.0, 0.0008247288060374558, -1.2087244943331653e-18, 3.321252251258819e-17, 7.530695310074617e-18, -0.0008054644567891955, 0.0, -0.000795965373981744, 4.3059641175166504e-17, -6.409579044701076e-17, 1.187787684489805e-17, 0.000777230248786509, 0.0, 0.0007679929258301854, 2.6546373217696846e-17, -3.17674479086254e-17, -2.9952547470235054e-17, -0.000749775383155793, 0.0, -0.0007407939410768449, -7.551704043272239e-18, 8.21702919139125e-19, -3.60220778590715e-17, 0.0007230828050523996, 0.0, 0.0007143518887460232, -1.0057981062788495e-17, 2.795832420121056e-17, -2.4053324470536538e-18, -0.000697136449161917, 0.0, -0.0006886506453156471, 2.6498462916617774e-17, -5.466321831149707e-17, 1.889425275678312e-17, 0.0006719205412082374, 0.0, 0.0006636749021708965, 1.4522621417413845e-17, -6.670324902623511e-18, -3.417845109236841e-17, -0.0006474201218225062, 0.0, -0.0006394098745658994, 1.5884899377963138e-18, -1.9300825262742734e-17, -2.3048631725710243e-17, 0.0006236208137124777, 0.0, 0.0006158410687930882, -1.6514621224951795e-17, 2.3405005949016464e-17, 7.398525910259056e-18, -0.0006005084724165499, 0.0, -0.0005929546896368265, -3.667210285419527e-17, -4.638532744538085e-17, 2.3660700711246405e-17, 0.0005780698265880346, 0.0, 0.0005707375821657479, 2.1410347582989768e-17, -6.371297870414673e-18, 2.716672393552589e-17, -0.0005562916048802435, 0.0, -0.0005491767660714686, -7.204901126833869e-18, -1.595677889165216e-17, -1.2912749274373341e-17, 0.0005351613508537412, 0.0, 0.0005282597849145532, -2.0857605645347134e-17, 3.6590559389409794e-17, -2.4904244649681954e-19, -0.0005146669573150575, 0.0, -0.0005079747061245143, -2.4988613453247183e-17, -3.915328073238483e-17, 1.2450892979354358e-17, 0.0004947964334860444, 0.0, 0.0004883095389232039, 1.2126567868881505e-17, -5.993928148800631e-18, 3.0730487675284025e-17, -0.00047553839976899326, 0.0, -0.00046925328206270933, -2.3902973537459485e-19, -1.3104811513621416e-17, -5.1593885239280255e-18, 0.0004568817967083305, 0.0, 0.0004507947014644742, -1.0763198029923641e-17, 3.0708183577247145e-17, -5.8476565603119604e-18, -0.0004388158267829567, 0.0, -0.0004329232615418732, -1.5807112140339264e-17, -4.6887654379049605e-17, 1.600189001353835e-17, 0.00042132995440624654, 0.0, 0.00041562848491594195, 5.0671003965757904e-18, 7.891863872211195e-18, 2.0945766555033035e-17, -0.0004044140223413706, 0.0, -0.0003989003016613424, 4.8502136399643866e-18, -1.069028454046893e-17, -1.0519448582919578e-17, 0.00038805807707831264, 0.0, 0.00038272884557954967, -1.3960060845900206e-17, 2.563376139147934e-17, -9.743089120021196e-18, -0.0003722524270415306, 0.0, -0.00036710454151034355, -1.911452764518354e-17, 8.189805229866057e-18, 1.8146488100480083e-17, 0.0003569876425899565, 0.0, 0.00035201801802031696, 9.769039430198209e-18, 6.2887597209426005e-18, 1.3333211797178946e-17, -0.00034225452691316605, 0.0, -0.00033746007829904556, 8.37661487222442e-18, -1.9583438136466376e-17, -4.69064470953862e-18, 0.0003280440578237176, 0.0, 0.0003234218747820705, -1.589097501956234e-17, 2.1293180757944082e-17, -3.2672275551688475e-18, -0.00031434744596481323, 0.0, -0.00030989458900876343, -1.2208222175869064e-17, 7.256797611284833e-18, 1.0557239156384675e-17, 0.0003011560474988073, 0.0, 0.0002968697517644614, 4.4776237815199824e-18, 4.9708591730761645e-18, 7.551809922390645e-18, -0.00028846150962635875, 0.0, -0.00028433892293833196, 2.6418620548762012e-18, -1.6179093607443135e-17, -4.013072428667725e-19, 0.000276255450444296, 0.0, 0.0002722939243540168, -1.682550382329005e-17, 2.6427148367287128e-17, -6.139966885946868e-18, -0.0002645298663992435, 0.0, -0.0002607267233543098, -6.976778775962157e-18, -2.0386548620374723e-18, 1.2133824724395432e-17, 0.00025327675393782556, 0.0, 0.0002496293745934963, 6.03640325286977e-19, 3.9008774760913655e-18, 1.0176665764258216e-17, -0.00024248835688922554, 0.0, -0.00023899416555650532, 5.2317085112932304e-18, -1.3331086770185297e-17, 2.6381219577365427e-18, 0.00023215696273837239, 0.0, 0.00022881338372826576, 1.5245042914109482e-17, 2.1951131797697336e-17, -8.015112129120371e-18, -0.0002222749899374321, 0.0, -0.00021907959308009595, -3.0880407957454667e-18, -1.4687714673560547e-18, -1.1439684532842983e-17, 0.00021283506066538393, 0.0, 0.00020978538668714464, -2.1494139324680165e-18, 9.830986986272305e-18, 5.9283678814012096e-18, -0.000203829855308868, 0.0, -0.00020092347403988242, 6.943305258113974e-18, -1.0985476349767666e-17, -8.634543952686445e-19, 0.00019525217066984624, 0.0, 0.00019248668104410172, 1.0388546423802449e-17, 1.8256518011200662e-17, -3.7864031239395394e-18, -0.00018709486175794154, 0.0, -0.000184467964572832, -5.471341493978924e-18, -1.031424533887018e-18, -7.345658315768955e-18, 0.00017935095820575953, 0.0, 0.0001768603251548484, 9.456538659786648e-19, 8.094769622109228e-18, 2.797817240000877e-18, -0.00017201353330165148, 0.0, -0.0001696568651823327, 8.013843234060715e-18, -1.458430593005315e-17, 1.3849559442230472e-18, 0.00016507574764546007, 0.0, 0.00016285080346278846, 6.734190690538118e-18, -5.816382102122249e-18, -5.242782391743784e-18, -0.00015853084914851934, 0.0, -0.00015643535880371928, -2.6596350643126687e-18, -7.008066469041669e-19, -8.641413584276121e-18, 0.0001523721730336547, 0.0, 0.00015040395373944193, -1.1015430834494895e-18, 6.723039468700291e-18, 5.011945751089556e-19, -0.00014659309817943722, 0.0, -0.00014474995259661227, -1.176499233388355e-17, 6.468980869721979e-18, -1.3158210158064777e-17, 0.00014118710532784462, 0.0, 0.00013946689432486892, -1.175551201688308e-17, 1.7465979845422508e-17, -6.2419553603425126e-18, -0.00013614770432468504, 0.0, -0.00013454828877002, -5.830370139870827e-19, -4.817739356296167e-18, -5.763253118558581e-18, 0.00013146853598300368, 0.0, 0.0001299877476412803, 1.2092739490550536e-17, -1.1199669806304597e-17, -1.2094891814504399e-17, -0.00012714321201201528, 0.0, -0.0001257789699593559, 5.581555865976102e-18, -1.0564690399342553e-17, 6.705680773353136e-19, 0.0001231654459843412, 0.0, 0.00012191568384878337, 5.403969701038011e-18, -6.813677474128059e-19, 6.651942054280439e-18, -0.0001195290096802637, 0.0, -0.00011839163926197216, 1.1027665042549708e-17, -1.951371177391183e-17, 9.669126765549767e-18, 0.00011622769670793787, 0.0, 0.00011520068073878065, -3.77166772850752e-18, 8.661205534792677e-18, 7.216937328529551e-19, -0.0001132553952629678, 0.0, -0.0001123366819228977, -6.30065044224805e-18, 5.295900208369183e-18, -1.060371843500403e-17, 0.00011060598626499996, 0.0, 0.00010979356738971546, -8.954878640486766e-18, 1.357228932808331e-17, -4.6343542416737736e-18, -0.00010827343066921458, 0.0, -0.00010756527626654133, -7.8351405820908305e-19, -3.630475856160537e-18, -1.933125847824948e-18, 0.00010625171853462234, 0.0, 0.00010564584954408929, 1.0170259250413992e-17, -5.9439875329080484e-18, 1.1245188728232777e-17, -0.000104534876300022, 0.0, -0.00010402931366115808, 7.278098339238686e-18, -1.195509911816355e-17, 3.1925281827716338e-18, 0.0001031169667840004, 0.0, 0.00010270974598824978, 1.9549601072738976e-18, 2.5492676639021684e-18, 5.9524012005086315e-18, -0.00010199211101280525, 0.0, -0.00010168126755161211, -1.0992760502241808e-17, -1.6640809281757984e-17, 8.08848470381505e-18, 0.00010115444456459954]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>75e3</value></param>
<param><key>decim</key><value>12</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>25e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value>airspy=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>48e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>interp</key><value>12</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
