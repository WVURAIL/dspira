<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0</value></param>
<param><key>fftaps</key><value>[0.0010319202328002777, -0.003086081884952957, 0.0020541818981442005, 0.0020541818981441953, -0.00308608188495296, 0.0010319202328002805]</value></param>
<param><key>fbtaps</key><value>[1.0, -4.955827857026481, 9.827089807224429, -9.746196752062607, 4.834438712577778, -0.959503870221139]</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0_0</value></param>
<param><key>fftaps</key><value>[0.0007574541113324438, -0.0037824765754322655, 0.006802714333444522, -0.003777691863679933, -0.0037776918636798973, 0.0068027143334445025, -0.003782476575432257, 0.0007574541113324417]</value></param>
<param><key>fbtaps</key><value>[1.0, -6.964848981937197, 20.792513106566282, -34.48974151988375, 34.33081834494503, -20.506402186592968, 6.805843777916458, -0.9681825410025177]</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0_1</value></param>
<param><key>fftaps</key><value>[0.0006227488811386783, -0.0031110936119317684, 0.005596790998082025, -0.003108446265872252, -0.003108446265872264, 0.00559679099808204, -0.0031110936119317758, 0.0006227488811386794]</value></param>
<param><key>fbtaps</key><value>[1.0, -6.971589706791631, 20.83182845521489, -34.58524802200348, 34.454503333082286, -20.596460793370884, 6.840799640559907, -0.9738329066882234]</value></param>
<param><key>oldstyle</key><value>False</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>name</key><value>"C"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>name</key><value>"CE"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>name</key><value>"CEG"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>iir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>iir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>iir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0_1</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
